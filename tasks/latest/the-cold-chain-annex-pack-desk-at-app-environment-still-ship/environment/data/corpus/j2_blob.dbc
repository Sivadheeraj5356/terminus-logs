VERSION "annex_dbc_3"
NS_ j2_NS: 1
BO_ j2_MSG: 8 j2
 SG_ CoolantFlow_j2 : 0|8@1+ (1,0) [0|255] "u" j2
 SG_ ProbeTemp_j2 : 3|8@1+ (1,0) [0|255] "u" j2
 SG_ DoorSeal_j2 : 6|8@1+ (1,0) [0|255] "u" j2
 SG_ FanDuty_j2 : 9|8@1+ (1,0) [0|255] "u" j2
 SG_ BatteryV_j2 : 12|8@1+ (1,0) [0|255] "u" j2
 SG_ CompressorHz_j2 : 15|8@1+ (1,0) [0|255] "u" j2
 SG_ HumidityPct_j2 : 18|8@1+ (1,0) [0|255] "u" j2
 SG_ AmbientC_j2 : 21|8@1+ (1,0) [0|255] "u" j2
 SG_ SetpointC_j2 : 24|8@1+ (1,0) [0|255] "u" j2
 SG_ AlarmMask_j2 : 27|8@1+ (1,0) [0|255] "u" j2
 SG_ ValvePos_j2 : 30|8@1+ (1,0) [0|255] "u" j2
 SG_ PumpRpm_j2 : 33|8@1+ (1,0) [0|255] "u" j2
 SG_ FilterDelta_j2 : 36|8@1+ (1,0) [0|255] "u" j2
 SG_ DefrostState_j2 : 39|8@1+ (1,0) [0|255] "u" j2
 SG_ EvapTemp_j2 : 42|8@1+ (1,0) [0|255] "u" j2
 SG_ CondPress_j2 : 45|8@1+ (1,0) [0|255] "u" j2
 SG_ OilLevel_j2 : 48|8@1+ (1,0) [0|255] "u" j2
 SG_ InverterKw_j2 : 51|8@1+ (1,0) [0|255] "u" j2
 SG_ GridPhase_j2 : 54|8@1+ (1,0) [0|255] "u" j2
 SG_ RelayMap_j2 : 57|8@1+ (1,0) [0|255] "u" j2
PEER j1
PEER j6
PEER j10
; blk 0 slice j2 calibration notes for field desk operators
PEER j3
PEER j4
; calib-peer noise for j2 (not lock preamble)
; map j2 r00c00 digest=0fd7982ed0d79486dcb5c8a62e0f32161da569b81fa3ba40b2d7f8c4f802246d range=[0,20] unit=raw
 SG_ Synth_j2_0_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r00c01 digest=4a79d8b72a02e70fa9c92bf2b7fced960877bb7e0b99fe7115bba5a52f81aebc range=[1,21] unit=raw
 SG_ Synth_j2_0_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r00c02 digest=e76612c6bd8adc0d325fcceb1a281dafff84d1ecd1bfd35725c10dda8c8df3de range=[2,22] unit=raw
 SG_ Synth_j2_0_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r00c03 digest=298da62b7388c875cee41ac824f28872c32adefd49a05a5ab272ca12284e8b36 range=[3,23] unit=raw
 SG_ Synth_j2_0_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r00c04 digest=a80e736be2a541022d1faf1ddaf2dd61ed8846d5701f377e2a6f54f8ac7cbab8 range=[4,24] unit=raw
 SG_ Synth_j2_0_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r00c05 digest=bf78b765f22b4bbff5fa0a4093eb63aeb21859843f70f5fdf905ff9e6259f49d range=[5,25] unit=raw
 SG_ Synth_j2_0_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r00c06 digest=b4120d7f689af033d1c4327be79b46a757dca44de3fc7651afbddd20980bfd81 range=[6,26] unit=raw
 SG_ Synth_j2_0_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r00c07 digest=c6e6c8f4f77bb33308cc671139f700fa84d03e4eba631a1ab59e04ed49f9de45 range=[7,27] unit=raw
 SG_ Synth_j2_0_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r00c08 digest=78c328eac1d615a8852f0712d001da1561451451fb9800c36f0604c3308eea32 range=[8,28] unit=raw
 SG_ Synth_j2_0_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r00c09 digest=d6c5605d3069caca84073cbb570d01b3f31add657f920bf4a469d4bf2a921f9e range=[9,29] unit=raw
 SG_ Synth_j2_0_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r00c10 digest=e0ddf5c21b6637e78a7648f37b3e8a63137269c34a85563a1b9bad574dfd8c24 range=[10,30] unit=raw
 SG_ Synth_j2_0_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r00c11 digest=6624736f2f851509537de74a11ce89957ff0d5d237637d351f546fea30984660 range=[11,31] unit=raw
 SG_ Synth_j2_0_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_0: 8 j2
; peer-ref j2->j1 blk=0 sticky=1
; peer-ref j2->j6 blk=0 sticky=1
; peer-ref j2->j10 blk=0 sticky=1
; blk 1 slice j2 calibration notes for field desk operators
; map j2 r01c00 digest=cf06000ce070cb742f357525005405ebb64fd1860759118c1e6d4bc1d3146be4 range=[0,20] unit=raw
 SG_ Synth_j2_1_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r01c01 digest=4d3f33c4af25f8d3238ffd5649236a115036ba481baa58ab146a8a495d7ece00 range=[1,21] unit=raw
 SG_ Synth_j2_1_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r01c02 digest=5ea433546e35e2d56e05d953e8518fc8621d089ab65b21c4c231e1b9d89763b9 range=[2,22] unit=raw
 SG_ Synth_j2_1_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r01c03 digest=e0f06045342239f7ff95dbfb7d639c16e2bf75d846a5018d5e9f8374855224e6 range=[3,23] unit=raw
 SG_ Synth_j2_1_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r01c04 digest=86563ef72541537167746448c2398267fe6ab79dce90f8fd5a928a85f420d601 range=[4,24] unit=raw
 SG_ Synth_j2_1_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r01c05 digest=a4f16b6ad34208175158ebab12836c05c1b1284c79a03c5448abb72fd2fbe85b range=[5,25] unit=raw
 SG_ Synth_j2_1_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r01c06 digest=c1654d663f76f4e79a4b3d406983986756450a66435f6e44762904b007cbbf8d range=[6,26] unit=raw
 SG_ Synth_j2_1_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r01c07 digest=38ba126c036a77d2ed2fa0c98287c921233cc60ebcec934752ef0ace5c5b60fd range=[7,27] unit=raw
 SG_ Synth_j2_1_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r01c08 digest=8f5c875ebfe7e78dd5b2c1aab5dd707ba51574f7a0866c3a6f72082e3b4b7258 range=[8,28] unit=raw
 SG_ Synth_j2_1_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r01c09 digest=56c88b848eb3f241f58a097049370b926460e42ac867efd2dd7fcfe0d7b066ca range=[9,29] unit=raw
 SG_ Synth_j2_1_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r01c10 digest=fd0fe51a8c04a91ffcbb623484ce34f88983165fe16ddd84ff1039e1b96af5a2 range=[10,30] unit=raw
 SG_ Synth_j2_1_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r01c11 digest=a6abdf8d8ec3aadd0abfef40c0376238d6595dea610aa1d7bda0360990240487 range=[11,31] unit=raw
 SG_ Synth_j2_1_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_1: 8 j2
; peer-ref j2->j1 blk=1 sticky=1
; peer-ref j2->j6 blk=1 sticky=1
; peer-ref j2->j10 blk=1 sticky=1
; blk 2 slice j2 calibration notes for field desk operators
; map j2 r02c00 digest=5d0a9425a2a625bca83f3da26a23bcc4b19bc2fe9eb46cde0969206b36973676 range=[0,20] unit=raw
 SG_ Synth_j2_2_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r02c01 digest=d20622026fcec9b35ed4f39348c5b9fec00c11b075f24f58347f1e03a2c66739 range=[1,21] unit=raw
 SG_ Synth_j2_2_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r02c02 digest=33726b546bed6c8488ebd486c785b3e39056d1d2ae7425dcefcdefaa088a7aac range=[2,22] unit=raw
 SG_ Synth_j2_2_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r02c03 digest=0bebbbd38830d0b1f3fe1f143e14036f3371f162c7f84725fbacc0a31bb1948d range=[3,23] unit=raw
 SG_ Synth_j2_2_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r02c04 digest=ac2d2efa8d3fe791038b93590abd4698804e8effb78ff623784303c6b1901deb range=[4,24] unit=raw
 SG_ Synth_j2_2_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r02c05 digest=5cdb3a7c20703c06cca31b412e922227ec44158bcac2505fac0cdb3991befc41 range=[5,25] unit=raw
 SG_ Synth_j2_2_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r02c06 digest=5bf5bca04962b7850538ba543a08c373d2ef2ca2fcb0138e60c96b8b7a2e7e14 range=[6,26] unit=raw
 SG_ Synth_j2_2_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r02c07 digest=cd8a87e4833c39b7bbc7cba558041aff5e4745a625002e427772deda4048d2f6 range=[7,27] unit=raw
 SG_ Synth_j2_2_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r02c08 digest=6963a4df6a310aab739b0b89a8e0bae0a4c6f7724ff28b854c653eb552f86994 range=[8,28] unit=raw
 SG_ Synth_j2_2_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r02c09 digest=792fd143e8a30dc910c4a978c55861fba0c43fb88e0e042fffe5ddcbdf793ac4 range=[9,29] unit=raw
 SG_ Synth_j2_2_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r02c10 digest=16e9da23423d40ccc100ff4586b8fda3638783a39d60406bf65716e280ca0638 range=[10,30] unit=raw
 SG_ Synth_j2_2_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r02c11 digest=efce7e2916539d54e561b2993e941de58f0462278416cba3734489bb791eebdf range=[11,31] unit=raw
 SG_ Synth_j2_2_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_2: 8 j2
; peer-ref j2->j1 blk=2 sticky=1
; peer-ref j2->j6 blk=2 sticky=1
; peer-ref j2->j10 blk=2 sticky=1
; blk 3 slice j2 calibration notes for field desk operators
; map j2 r03c00 digest=2e418cdcfc7ecf4a3f6178bf0c9972e6f060be2a1458b27c798502263d053e74 range=[0,20] unit=raw
 SG_ Synth_j2_3_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r03c01 digest=eab8840ec23e2f71eb853b73788671facd5692e83d3b9229d3b8ee3736aa5178 range=[1,21] unit=raw
 SG_ Synth_j2_3_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r03c02 digest=f8d04364851666f8f9e566a17159e55c55a974ef490647c8c97f7a2e391b620f range=[2,22] unit=raw
 SG_ Synth_j2_3_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r03c03 digest=68f700f2057d2eb14f368b1bd612318d70085f8f9fe4f75d34cd8fe3154a6af5 range=[3,23] unit=raw
 SG_ Synth_j2_3_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r03c04 digest=6db62c73628e53b7350a987c3d9f561a425ba1d36a7fae2968550e7053790b91 range=[4,24] unit=raw
 SG_ Synth_j2_3_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r03c05 digest=ec39534568b61961fb82f3c411140d581b0a6a7ac94b596b0c41966ca27da77b range=[5,25] unit=raw
 SG_ Synth_j2_3_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r03c06 digest=51f3c9fdf87dba06fa6f9408606763ec7a0ee804a3a53ed0a7907b8d1c0b0e20 range=[6,26] unit=raw
 SG_ Synth_j2_3_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r03c07 digest=2c5c585581a925ee9925e45f5cbb3f79398d30359c60b9571e1f781290f84a94 range=[7,27] unit=raw
 SG_ Synth_j2_3_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r03c08 digest=d009512ffc5ee49f63618cf81a636f3b013bb1731e21683fffeac1e4701accee range=[8,28] unit=raw
 SG_ Synth_j2_3_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r03c09 digest=a5b6a3360e642ccdf541ee27a0328092a6cff13a7066497791cfa1072808c30b range=[9,29] unit=raw
 SG_ Synth_j2_3_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r03c10 digest=ac7cd84c9fc320765e5e3144bc50a52a18276c9d8ea6f7fefbf811443c3eaac4 range=[10,30] unit=raw
 SG_ Synth_j2_3_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r03c11 digest=665c2bbac9405e79ba0788161e4df88861fd4b053c5ac23cc5f046ec43d369ec range=[11,31] unit=raw
 SG_ Synth_j2_3_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_3: 8 j2
; peer-ref j2->j1 blk=3 sticky=1
; peer-ref j2->j6 blk=3 sticky=1
; peer-ref j2->j10 blk=3 sticky=1
; blk 4 slice j2 calibration notes for field desk operators
; map j2 r04c00 digest=ec72ca2ca7f09850a6175e3e9620d9f1a7208ae7355321ca869bf35bf917ab70 range=[0,20] unit=raw
 SG_ Synth_j2_4_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r04c01 digest=ea4daffca29d301ec8b06bb8a8093fea95955831003d91e967e7d03665789ed3 range=[1,21] unit=raw
 SG_ Synth_j2_4_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r04c02 digest=8c97a37c0875208b224abaac27a8dcdd181c53624d37884b108ab0f040b704d5 range=[2,22] unit=raw
 SG_ Synth_j2_4_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r04c03 digest=78c70bb0ac1d7f21ffc0930e23f1268842d75472b4cc1466d6154000e42a909f range=[3,23] unit=raw
 SG_ Synth_j2_4_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r04c04 digest=d007648ebf4243274d7130002247a25d8584d90447411cbaf6b5d7ce9b7b2f92 range=[4,24] unit=raw
 SG_ Synth_j2_4_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r04c05 digest=124e133cf136066d86acd6ad0caf7985e1e2c461749351740a4f487ef9d091e8 range=[5,25] unit=raw
 SG_ Synth_j2_4_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r04c06 digest=dc8b899ffefaa70aa7f32412a0edcc345729af0c6af1e5627dbd165745ad8d55 range=[6,26] unit=raw
 SG_ Synth_j2_4_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r04c07 digest=c57b89d16d71f2852a14c59fded92a797214321eeba670ad379c1d189509198d range=[7,27] unit=raw
 SG_ Synth_j2_4_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r04c08 digest=241e73c1d3dd01ba1634550b805fe2b3df5c263338a65ed11990d2b2103b7b64 range=[8,28] unit=raw
 SG_ Synth_j2_4_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r04c09 digest=f0f441e3701519861772b3e3875cca7a7003b8467bf8537984faee9f93b407d9 range=[9,29] unit=raw
 SG_ Synth_j2_4_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r04c10 digest=77fc1cc8bd6e6216929169b81cdfedb8c3747239e919a105c47a1bb924668e32 range=[10,30] unit=raw
 SG_ Synth_j2_4_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r04c11 digest=dcff2f77379587857f368dc20864b143158d76bc3abe60b44e9acf554fc047d9 range=[11,31] unit=raw
 SG_ Synth_j2_4_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_4: 8 j2
; peer-ref j2->j1 blk=4 sticky=1
; peer-ref j2->j6 blk=4 sticky=1
; peer-ref j2->j10 blk=4 sticky=1
; blk 5 slice j2 calibration notes for field desk operators
; map j2 r05c00 digest=046939709c5b22391f1146c3d7d57c846c55f49a15b21cc07f90ad1eb8d63838 range=[0,20] unit=raw
 SG_ Synth_j2_5_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r05c01 digest=ebd8106add17374dde9f451b413041bfb397bb9c2192aeb49c50bb540171d6a4 range=[1,21] unit=raw
 SG_ Synth_j2_5_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r05c02 digest=70cff5e56d432f537b5f2d015f91f932db28db1d890f82fc52acb67bf4a7ae66 range=[2,22] unit=raw
 SG_ Synth_j2_5_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r05c03 digest=e39644d493a84bf6418ab0dbb47156322d6f326407fe08398076f37118b8d7c5 range=[3,23] unit=raw
 SG_ Synth_j2_5_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r05c04 digest=3e61ce13d28dc02d2d262793b81e4d2e9495821ce1aefdde3917fb008b5117f9 range=[4,24] unit=raw
 SG_ Synth_j2_5_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r05c05 digest=e57a86b927bae916b01c0e72b308fb3db3525bb32c5c0e6ea4e9456d85644607 range=[5,25] unit=raw
 SG_ Synth_j2_5_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r05c06 digest=b4ac361b0164a54903d8c86a9580384654923cef7348b0a676a3e05e332e8a10 range=[6,26] unit=raw
 SG_ Synth_j2_5_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r05c07 digest=16b0095cd3e3bb090ff191de553e545ee5fa0b9756267573a907eb9bf8ec1101 range=[7,27] unit=raw
 SG_ Synth_j2_5_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r05c08 digest=5e428e7ebd48421c940acc30611d6c5736e66734b4e0d930f28eb2d428d1e85c range=[8,28] unit=raw
 SG_ Synth_j2_5_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r05c09 digest=d8a207fff96e1de7c1129b8d633e54e243b6f75ba3c81abd09d1be8186100cc8 range=[9,29] unit=raw
 SG_ Synth_j2_5_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r05c10 digest=9080197d09abb02cdcf6d83e96fb424acb764ea22daa5bc2ea00e69e25f6789f range=[10,30] unit=raw
 SG_ Synth_j2_5_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r05c11 digest=b795317801ad7380d980d9fc09306814089bd41c73798480d91c02a96c27d688 range=[11,31] unit=raw
 SG_ Synth_j2_5_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_5: 8 j2
; peer-ref j2->j1 blk=5 sticky=1
; peer-ref j2->j6 blk=5 sticky=1
; peer-ref j2->j10 blk=5 sticky=1
; blk 6 slice j2 calibration notes for field desk operators
; map j2 r06c00 digest=c249efff75ca030183097d7bac7f72c3e2b1b017415c0728ba98d5828883e0bf range=[0,20] unit=raw
 SG_ Synth_j2_6_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r06c01 digest=d317baddb4a2049959edc53bb4c2dd00d15a4c9a5740fa151d4321ebdc2be27e range=[1,21] unit=raw
 SG_ Synth_j2_6_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r06c02 digest=adecc82942306060109deca29f2bd61afe945107f8001c5ac35a01be7041bc0a range=[2,22] unit=raw
 SG_ Synth_j2_6_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r06c03 digest=a58801df1d661a2c95ad03b7fb33c5e77bd7da42240a5d1dfcb1edb22134e76e range=[3,23] unit=raw
 SG_ Synth_j2_6_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r06c04 digest=137f4171a7d1cd7647ff9b4fd1fa4a876fbb340f91ab8780e7046e38bf003e92 range=[4,24] unit=raw
 SG_ Synth_j2_6_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r06c05 digest=a1c8455d2a070f5d6d236094cfb4554baed4bd9ceef103e2dfa71ba98789effd range=[5,25] unit=raw
 SG_ Synth_j2_6_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r06c06 digest=16292d75e68fea20bea9c9a86d25d2ad604a878c70ab6ba7b6d460111d2eea21 range=[6,26] unit=raw
 SG_ Synth_j2_6_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r06c07 digest=c6eb6e859ce3121644d4adfb381d17e0244a24c57597b302b17f28431a014029 range=[7,27] unit=raw
 SG_ Synth_j2_6_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r06c08 digest=1915013cbfae4cc5afcf054850b39ef9e5454770bee35664d2ba0bd75153ccd3 range=[8,28] unit=raw
 SG_ Synth_j2_6_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r06c09 digest=2daf9e25281fb67c4ea7880b1fabee2f56c4954ab2ca561bcf10b2ceb61b4271 range=[9,29] unit=raw
 SG_ Synth_j2_6_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r06c10 digest=5aa7e0f8126850d7765c1a7d0d5a4a535b5d4eae58f498338b95307891d7823a range=[10,30] unit=raw
 SG_ Synth_j2_6_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r06c11 digest=2cc1b5df024134b5dc10a473718511c3e2627d04e2f8d23fff30f03bd7eee904 range=[11,31] unit=raw
 SG_ Synth_j2_6_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_6: 8 j2
; peer-ref j2->j1 blk=6 sticky=1
; peer-ref j2->j6 blk=6 sticky=1
; peer-ref j2->j10 blk=6 sticky=1
; blk 7 slice j2 calibration notes for field desk operators
; map j2 r07c00 digest=d0dd9a4d41946604020e8bf0f3d650a1777eaebd3543cb5fb6e25a2c63f42085 range=[0,20] unit=raw
 SG_ Synth_j2_7_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r07c01 digest=58a426a01cbc0d2ba64c4bb1cdd7b964992f0c0889001fafa55eb8bb44180922 range=[1,21] unit=raw
 SG_ Synth_j2_7_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r07c02 digest=f68ab5a5129677b82dcde4f49a4c0dfcd1610f80395196ab7f190b596a81c4d6 range=[2,22] unit=raw
 SG_ Synth_j2_7_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r07c03 digest=42302bcf1d72145252ce90a945ab0bc5e3a60c38c4cd8b6311b4ffaaa6a10e5e range=[3,23] unit=raw
 SG_ Synth_j2_7_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r07c04 digest=1f23cdf523adcd2e06196d6fe17fd1e44dc50c5d20f00f0ec14ab67a1db101a6 range=[4,24] unit=raw
 SG_ Synth_j2_7_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r07c05 digest=1502b6d34eaf2af1a40122f80a9cd564cade84f54f886f9a097038a7b5c40d3b range=[5,25] unit=raw
 SG_ Synth_j2_7_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r07c06 digest=919193a853a7d4bbcdb1a9798f64d6ad11e695e8e5b486af350f2b25ed935082 range=[6,26] unit=raw
 SG_ Synth_j2_7_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r07c07 digest=f465e5a2fd3c2a2319f3be1c3d7b1f9676a730b3c15f9414051b2ccc8cf179a5 range=[7,27] unit=raw
 SG_ Synth_j2_7_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r07c08 digest=032f1176aa34f331776bf1023c74d50cb3a48540e4f8cdcc074677417b63f4c6 range=[8,28] unit=raw
 SG_ Synth_j2_7_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r07c09 digest=21969a8fb1694b2ea3035099ebf7d9a752d9a16f49f19c46ad693e7fc538266f range=[9,29] unit=raw
 SG_ Synth_j2_7_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r07c10 digest=51039da420f68bb667b3148a217b42810835a5211e14598c419c8f3b78525aaf range=[10,30] unit=raw
 SG_ Synth_j2_7_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r07c11 digest=09a5edef474e61173ce06c38200ac237b1be2a7fd546491068d8f2944747d48d range=[11,31] unit=raw
 SG_ Synth_j2_7_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_7: 8 j2
; peer-ref j2->j1 blk=7 sticky=1
; peer-ref j2->j6 blk=7 sticky=1
; peer-ref j2->j10 blk=7 sticky=1
; blk 8 slice j2 calibration notes for field desk operators
; map j2 r08c00 digest=1bb114a334c888c62e143a0721af702425d932152e0509942922b9a08226644c range=[0,20] unit=raw
 SG_ Synth_j2_8_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r08c01 digest=60f66a13bfd8ee3b1e075f64008a23dd5c7e34678bbaf1393c95b831a3fccf7e range=[1,21] unit=raw
 SG_ Synth_j2_8_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r08c02 digest=82e8d2bbe150243d62cc1814456570f64de670e2f2e2749890f1092f3d7f9506 range=[2,22] unit=raw
 SG_ Synth_j2_8_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r08c03 digest=8ea0e8c38a23957e1e472b3daa97e63c13d7d35d0730445ada144f86eafd6fe3 range=[3,23] unit=raw
 SG_ Synth_j2_8_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r08c04 digest=ca9ac176b67290d7f293016fb8488d81e9335d6a65f838aa669b901578651d4b range=[4,24] unit=raw
 SG_ Synth_j2_8_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r08c05 digest=02e559593aa9f4e51aee02cc7c378b32203fa3794a40e5cf20c09b4f78631730 range=[5,25] unit=raw
 SG_ Synth_j2_8_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r08c06 digest=fde59448e4f6aa87d68f72adbf41cba6820bd3b834567b3fd81f430d6e4a2e5e range=[6,26] unit=raw
 SG_ Synth_j2_8_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r08c07 digest=cc0c4cec6708d9eb3b24ff4b3e00b7e003348804ca8abee9c206294de9c99507 range=[7,27] unit=raw
 SG_ Synth_j2_8_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r08c08 digest=5d19906fb10b3ab8d2fc73f01702acd1165a39ceb76a1a0a03d650d2a19a1635 range=[8,28] unit=raw
 SG_ Synth_j2_8_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r08c09 digest=4da455f3ea4f9a6a660e4f4a0d8ee088260e9964e9234f9321d2d2d6fd91b3a3 range=[9,29] unit=raw
 SG_ Synth_j2_8_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r08c10 digest=06e3c1a19a03d9eee0b1d27bc5d60dfac01cc15803b7fe538619886d8533bc17 range=[10,30] unit=raw
 SG_ Synth_j2_8_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r08c11 digest=9e58b4a9711d36dd3f657ca4d8cb373c66d9a84ecba463020e03c5cbc9d826ac range=[11,31] unit=raw
 SG_ Synth_j2_8_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_8: 8 j2
; peer-ref j2->j1 blk=8 sticky=1
; peer-ref j2->j6 blk=8 sticky=1
; peer-ref j2->j10 blk=8 sticky=1
; blk 9 slice j2 calibration notes for field desk operators
; map j2 r09c00 digest=ff884372183109e1e8e0f7e1d80b12c7fedcbc82bc72b331312df25805ce173e range=[0,20] unit=raw
 SG_ Synth_j2_9_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r09c01 digest=e58f47b66ec5f77331ec516443a1ee96bc52436cdfdb3cd1ca8416376cec7a6a range=[1,21] unit=raw
 SG_ Synth_j2_9_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r09c02 digest=82924134889a5ef62f5a83518f8b4c0babdc92beb58b468f216e766c5f8ebf17 range=[2,22] unit=raw
 SG_ Synth_j2_9_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r09c03 digest=19d8b5d98034daace658d4c45e9a012fc96151bc683e3935b78a8944d44f2986 range=[3,23] unit=raw
 SG_ Synth_j2_9_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r09c04 digest=da94c58f40a0a02c4b8cd1b6d295533b170de09f2e9ff15714a1c842c5bb4608 range=[4,24] unit=raw
 SG_ Synth_j2_9_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r09c05 digest=5af599b0996fb3a40d2c9bbee0fb2a8d9139f93a26e3ddc1b94f4c765e9fc965 range=[5,25] unit=raw
 SG_ Synth_j2_9_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r09c06 digest=0904e397df9d302eda8afa8a5a2343a70d525de50f27a1386b7d6794ea82b770 range=[6,26] unit=raw
 SG_ Synth_j2_9_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r09c07 digest=3de8a04a416861ec0c793ba64e8f700a586d9496326b3ce59f77517adce74124 range=[7,27] unit=raw
 SG_ Synth_j2_9_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r09c08 digest=3ab46adf7c5c6eaba96d98e45689a4eef888c51530c0753ff26e0b3004285f79 range=[8,28] unit=raw
 SG_ Synth_j2_9_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r09c09 digest=1d04f7bfa6db50f992f9c91c873f079b0e4b45f481ed4a0bd076b5b40edc1bd0 range=[9,29] unit=raw
 SG_ Synth_j2_9_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r09c10 digest=3a9028b42d9441e65ec4ceb5eeb48d4fe8ac87a8de74e00f787346126a971bf3 range=[10,30] unit=raw
 SG_ Synth_j2_9_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r09c11 digest=0026310dcac4a4ef12500a80458f46017442a08875f95a6257fcb6d830917426 range=[11,31] unit=raw
 SG_ Synth_j2_9_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_9: 8 j2
; peer-ref j2->j1 blk=9 sticky=1
; peer-ref j2->j6 blk=9 sticky=1
; peer-ref j2->j10 blk=9 sticky=1
; blk 10 slice j2 calibration notes for field desk operators
; map j2 r10c00 digest=e3ac8c2e65dc85dfbafb3f51c5d9d0b918f0cd3f897c85f257b1d99bd1f1199f range=[0,20] unit=raw
 SG_ Synth_j2_10_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r10c01 digest=b1e22ad0e28cc84cbaf853a91d3a9245045f3773ca02a749623e9d5e35312ffe range=[1,21] unit=raw
 SG_ Synth_j2_10_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r10c02 digest=d04e8e7ae251b9b1fea73cd506acc11e26b2bdc8b6d2ffb217cb756e4f8eda88 range=[2,22] unit=raw
 SG_ Synth_j2_10_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r10c03 digest=17b8535c0fd104a762672bde6cb7f62aa9b6dd9d6594bee24ba0b7a4152ae8ac range=[3,23] unit=raw
 SG_ Synth_j2_10_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r10c04 digest=a23c2b06319bc97f913811ec031bef9bd34b055242ab575c00e48ee908d322f9 range=[4,24] unit=raw
 SG_ Synth_j2_10_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r10c05 digest=fd950a795ae7a44e31fe2f174291096f56d809032aebc7a33a6e0be2c7eb40f0 range=[5,25] unit=raw
 SG_ Synth_j2_10_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r10c06 digest=cbd928d8abac85ae851c29b5f240ba6f9f7500bbb120e4fc937941490f6d5274 range=[6,26] unit=raw
 SG_ Synth_j2_10_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r10c07 digest=46eb15f8866c98b05718c85b4118b1a63a300858944391b202f71c3246196c02 range=[7,27] unit=raw
 SG_ Synth_j2_10_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r10c08 digest=4ef2ef7eeeddd6e16ded326f5c4043bf824480a6ba90a6845832a8951801364b range=[8,28] unit=raw
 SG_ Synth_j2_10_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r10c09 digest=3aa4bbe149c39376509f311ec4a383bb7d1b8e09e6d2fac65c80117df1b3a16d range=[9,29] unit=raw
 SG_ Synth_j2_10_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r10c10 digest=200d8d72a869515cffee5c282475cf93ec55cb04d885adb73a067c4561fab4d0 range=[10,30] unit=raw
 SG_ Synth_j2_10_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r10c11 digest=4994cd98505070653a240a4d6a4ea74a3cf7d919d3a94b4448a4371736548ae2 range=[11,31] unit=raw
 SG_ Synth_j2_10_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_10: 8 j2
; peer-ref j2->j1 blk=10 sticky=1
; peer-ref j2->j6 blk=10 sticky=1
; peer-ref j2->j10 blk=10 sticky=1
; blk 11 slice j2 calibration notes for field desk operators
; map j2 r11c00 digest=24feb900772c8d5af3233441b7b2a1b4a0d6e428a13814d2301a30c436a545e3 range=[0,20] unit=raw
 SG_ Synth_j2_11_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r11c01 digest=d54e01b5a8c7366ae983e07132378cf76f89911b08ea6b082adeed7d277dbb9c range=[1,21] unit=raw
 SG_ Synth_j2_11_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r11c02 digest=2d1bc4fba2afc4ce666e2b91a594064f190a0d068ebb9bc15558394cb0a0cad7 range=[2,22] unit=raw
 SG_ Synth_j2_11_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r11c03 digest=9ebbcfb4d38313d890215fe96a0be6090c4ddb1631e1a8875f083b16180d8738 range=[3,23] unit=raw
 SG_ Synth_j2_11_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r11c04 digest=90fbed4c0c9943f8f985d6ddf5bde71b670638053de19b4ec363c486f472dca8 range=[4,24] unit=raw
 SG_ Synth_j2_11_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r11c05 digest=4bafa0819c174a072f9cb5837c2473145e72d762a672e870fd3e99776c99ed8d range=[5,25] unit=raw
 SG_ Synth_j2_11_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r11c06 digest=97634e93c96be10a31bbe386b81f30d501eee9b5facf1c3ed21a7ea9e2937572 range=[6,26] unit=raw
 SG_ Synth_j2_11_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r11c07 digest=8f86dcd0af6f9ff7fe51502b79cf6ab220d316705d96a7d3cb23b71d0e5eccda range=[7,27] unit=raw
 SG_ Synth_j2_11_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r11c08 digest=76d9e6af38816655f79971115dca8738a4dbd2e00a3f5a3ca0e68be7036866ea range=[8,28] unit=raw
 SG_ Synth_j2_11_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r11c09 digest=5dc75593d0c66d4c6e32e5a523ac695cac4ae3c37a27861305a5135da1b6ae8d range=[9,29] unit=raw
 SG_ Synth_j2_11_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r11c10 digest=57dd690ad3e4ae5219dededa84fad37ea2f72ef4b23663d38b668a64eccc064a range=[10,30] unit=raw
 SG_ Synth_j2_11_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r11c11 digest=386817f7dc0f7eea10bd71289dbc5d6fe9badfec42d19cb382015c895f5e7544 range=[11,31] unit=raw
 SG_ Synth_j2_11_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_11: 8 j2
; peer-ref j2->j1 blk=11 sticky=1
; peer-ref j2->j6 blk=11 sticky=1
; peer-ref j2->j10 blk=11 sticky=1
; blk 12 slice j2 calibration notes for field desk operators
; map j2 r12c00 digest=e035c0a2d5e2ac0c53c5aefea207995d9573743c35fc52d9970847db4f5abb50 range=[0,20] unit=raw
 SG_ Synth_j2_12_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r12c01 digest=eaf29b20113b3ea73f7244022cdb66e79d4d5cf97a4cfcaef2d6d0b745a9fd63 range=[1,21] unit=raw
 SG_ Synth_j2_12_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r12c02 digest=fe000b81e9ca7b6dc1b6d0f4428bbb6320c9e4263c82f7cf42abf757a5ecd2a5 range=[2,22] unit=raw
 SG_ Synth_j2_12_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r12c03 digest=4d6c16536fb0ef1c503b1d4fadb3b6a18023290c567674296e18b2646fd783b1 range=[3,23] unit=raw
 SG_ Synth_j2_12_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r12c04 digest=d428a9940027cb7309d4c926b7b9e74df28eaadf2eac721c7b058b198d43f972 range=[4,24] unit=raw
 SG_ Synth_j2_12_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r12c05 digest=ce0f15bfaab3f3f86dd4724c08880f2c25eb821d9f99392efa3e8f7f509e4f07 range=[5,25] unit=raw
 SG_ Synth_j2_12_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r12c06 digest=b91589960af4390a0179fbcabd3047ec0471cbe3663ca24556872edbb5161fef range=[6,26] unit=raw
 SG_ Synth_j2_12_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r12c07 digest=daa822c729ee264150f7ee21b1eb18ff4109df8535eef2566cc29f48433454d2 range=[7,27] unit=raw
 SG_ Synth_j2_12_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r12c08 digest=45b4677ab0669a619f05b917a937950a362905e4d9aa3a6664bf117ed62792a8 range=[8,28] unit=raw
 SG_ Synth_j2_12_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r12c09 digest=9e346d1128ab872add98fb37802e34e68c6309fddb2074150d548b95abc8c03c range=[9,29] unit=raw
 SG_ Synth_j2_12_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r12c10 digest=1f3a927bed14d8b75107a0233ca28f6530eb5d2c95e1494f6a6c06ed6c2a5ada range=[10,30] unit=raw
 SG_ Synth_j2_12_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r12c11 digest=0061e40c97eac80c953b4950f98b10ed983e8be4709dec8515b77505cd03f72a range=[11,31] unit=raw
 SG_ Synth_j2_12_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_12: 8 j2
; peer-ref j2->j1 blk=12 sticky=1
; peer-ref j2->j6 blk=12 sticky=1
; peer-ref j2->j10 blk=12 sticky=1
; blk 13 slice j2 calibration notes for field desk operators
; map j2 r13c00 digest=407fb031921ea3b6eeeae6acd2605eab247f8356b6daa8071b6f7ceaaf1c8ab4 range=[0,20] unit=raw
 SG_ Synth_j2_13_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r13c01 digest=73f067bfff5fe7834222ae0e431fb0bf4fe7008430497664cb3f21187a56be1d range=[1,21] unit=raw
 SG_ Synth_j2_13_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r13c02 digest=a2b6986abb337a715b293d96f15e77b479fe5f89db1cc185c8513fc2cd706813 range=[2,22] unit=raw
 SG_ Synth_j2_13_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r13c03 digest=952e499cc77969fecd3b017b27fe21de25d5a93b300bc810cc1313b09fd61b66 range=[3,23] unit=raw
 SG_ Synth_j2_13_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r13c04 digest=98ffc28a8859d521deeb48e2f5d49823101f2254f9c771096310967289d1db31 range=[4,24] unit=raw
 SG_ Synth_j2_13_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r13c05 digest=00ac9b4f18345c6c847964a254df1f2dddd0b38718c586b002138a959ded1e46 range=[5,25] unit=raw
 SG_ Synth_j2_13_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r13c06 digest=0161e503ec5b688ae5f2e45f23b6e3d85073844d75dacf12ed98943e5b9e3687 range=[6,26] unit=raw
 SG_ Synth_j2_13_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r13c07 digest=c18e0b5530276d016b440e2193ee077973362b9bd046f6a6db5377d8d07a24c2 range=[7,27] unit=raw
 SG_ Synth_j2_13_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r13c08 digest=0a539b9bfacbbf9ed2aff7b12b468f109f9dc4c7056e741a17e707b19e5a42c0 range=[8,28] unit=raw
 SG_ Synth_j2_13_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r13c09 digest=6fb6bd08f6ffa523b869d9494095ff839eb04aadbdbebb1d39caae046280e6ba range=[9,29] unit=raw
 SG_ Synth_j2_13_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r13c10 digest=cbd71d77b6e0b7e847598eebf0f673360e88be3c180b0b88e987237c4054949d range=[10,30] unit=raw
 SG_ Synth_j2_13_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r13c11 digest=91dab6ae520334069b8e36454aee3cb1009aa53a1c175c340fd4b9f1be58f835 range=[11,31] unit=raw
 SG_ Synth_j2_13_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_13: 8 j2
; peer-ref j2->j1 blk=13 sticky=1
; peer-ref j2->j6 blk=13 sticky=1
; peer-ref j2->j10 blk=13 sticky=1
; blk 14 slice j2 calibration notes for field desk operators
; map j2 r14c00 digest=a2d4a381584602b1a681c83894ed2f9be7a9fb3385f9940641ff7cf834108799 range=[0,20] unit=raw
 SG_ Synth_j2_14_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r14c01 digest=ae3b210e0d3603bc65f59e927acda37a614bf45d11a24363694a4a5eccb3f7e1 range=[1,21] unit=raw
 SG_ Synth_j2_14_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r14c02 digest=d96da3ba0d44475ea55000282622ba4b979e4f01d6e825eadf5a01b99b1494cc range=[2,22] unit=raw
 SG_ Synth_j2_14_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r14c03 digest=4675e74c588271ec4ec7c4b8d79d010b5e0712239051a610fe4bd37fd7d78e23 range=[3,23] unit=raw
 SG_ Synth_j2_14_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r14c04 digest=81acc213a3b8fcc92f0ee5ee05caf9f490adcada2f8eafe16a32cadc664f41a2 range=[4,24] unit=raw
 SG_ Synth_j2_14_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r14c05 digest=b3ff239a3553631be86a79fac09e80ce5fb64076bb80a6042a81060222bb45b6 range=[5,25] unit=raw
 SG_ Synth_j2_14_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r14c06 digest=512cfe93ae18fa233db84b09d7bed6a9004ffc218e276907f3ce1421ebfbaf2f range=[6,26] unit=raw
 SG_ Synth_j2_14_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r14c07 digest=362a60f56b7a1199140f8c80a3b74b4c04f1ab76be7f7eec470018a249f67880 range=[7,27] unit=raw
 SG_ Synth_j2_14_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r14c08 digest=ddc7eaafe094434e3d4ca689d1c5a4418152cd24f482570ca424d984c4deede3 range=[8,28] unit=raw
 SG_ Synth_j2_14_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r14c09 digest=dad4bbc8c4406a9ed0f7f76166cae956ef1c2a04498c498adb7883a556c560d5 range=[9,29] unit=raw
 SG_ Synth_j2_14_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r14c10 digest=49b01eb13dad69fe99bf8898558e4490d44ef9f7db558ca9b377c928b115f3c2 range=[10,30] unit=raw
 SG_ Synth_j2_14_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r14c11 digest=f5c0fe4be4fb352f4a73102689678d93b12beb41b3fe139cea1a9bd8f88cde0c range=[11,31] unit=raw
 SG_ Synth_j2_14_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_14: 8 j2
; peer-ref j2->j1 blk=14 sticky=1
; peer-ref j2->j6 blk=14 sticky=1
; peer-ref j2->j10 blk=14 sticky=1
; blk 15 slice j2 calibration notes for field desk operators
; map j2 r15c00 digest=6fa24f5b44edf8db3839665d312551038b697e3ced6b92db6f9b00333cb8b2b3 range=[0,20] unit=raw
 SG_ Synth_j2_15_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r15c01 digest=d00138c167fd0c1a138cd9fa4131321d04792dd308806fbd22f28f48a290a8b9 range=[1,21] unit=raw
 SG_ Synth_j2_15_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r15c02 digest=34bf6cb6cb0a39c15042fb77bcc913c10035cb449048d43a93e510b9a287292b range=[2,22] unit=raw
 SG_ Synth_j2_15_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r15c03 digest=de69ab2de5f8fa0b7710c7480748905d6d4729e4978ec987ef6f7e369e061f1d range=[3,23] unit=raw
 SG_ Synth_j2_15_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r15c04 digest=cf4c3c99e35b1c3d0422c27d314f098fcb1c383d00202d8c4b89263c4b1198f7 range=[4,24] unit=raw
 SG_ Synth_j2_15_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r15c05 digest=2ff003b3cf2f4cf55825192245dea59f4f8323b5811eb06feb0a2faae9da890e range=[5,25] unit=raw
 SG_ Synth_j2_15_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r15c06 digest=b7ca5aff1c38cb6f75baa35052890eb58a92f1ac349444fc51b9ca04e8ee8f55 range=[6,26] unit=raw
 SG_ Synth_j2_15_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r15c07 digest=d452eb43e46cbcbf15e68c3e2595f87017ecd2d03b158c751a47b197cb095766 range=[7,27] unit=raw
 SG_ Synth_j2_15_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r15c08 digest=4cd67c5dfccec8f3247bd4a417be9737d52839cb736d9b1f0a3e9ada376a5701 range=[8,28] unit=raw
 SG_ Synth_j2_15_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r15c09 digest=6276faa3ab2634f1fbee89af36053a1ae0e47459a9b45e033efec39f18de891a range=[9,29] unit=raw
 SG_ Synth_j2_15_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r15c10 digest=e8abc29f7a81ee4941be30e997097803cb01773e23b8cbe001c0402069f1819e range=[10,30] unit=raw
 SG_ Synth_j2_15_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r15c11 digest=27254e70cda46a5f8e6a812646d31f194bc5bbc30b80d753445ad1404ee295af range=[11,31] unit=raw
 SG_ Synth_j2_15_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_15: 8 j2
; peer-ref j2->j1 blk=15 sticky=1
; peer-ref j2->j6 blk=15 sticky=1
; peer-ref j2->j10 blk=15 sticky=1
; blk 16 slice j2 calibration notes for field desk operators
; map j2 r16c00 digest=e4fe98c893f44e7f2f55065eb90722df2e23b4e5d68a7ba5d2a5d45c734626b0 range=[0,20] unit=raw
 SG_ Synth_j2_16_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r16c01 digest=087a4136620d932ce2f2a29ad7bcd87f3bcfe1d67c302fbaf2b20d35bf4ee6ac range=[1,21] unit=raw
 SG_ Synth_j2_16_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r16c02 digest=6ff013b71013f981879569751906ff953ef392edba7d835c696e2bfa5d2e16ab range=[2,22] unit=raw
 SG_ Synth_j2_16_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r16c03 digest=afa119da2b35c882d6e2dad7fb1250cefe3aadfe0d4c2acb3a1f3a6d4af6b620 range=[3,23] unit=raw
 SG_ Synth_j2_16_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r16c04 digest=3c871143eb5c5000a98b3ef185a35f1010e803dfa23d6fbbaf7feb64c836c443 range=[4,24] unit=raw
 SG_ Synth_j2_16_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r16c05 digest=b5fbc291863f5b63f287e7cf931ec04e0f93adcd18c568d70e79d52d0a646c84 range=[5,25] unit=raw
 SG_ Synth_j2_16_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r16c06 digest=e80fc61d565749abb299fae7510cee0e32f3873b5173b51188c2240f6190d660 range=[6,26] unit=raw
 SG_ Synth_j2_16_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r16c07 digest=f26603765feaf3b090f21dcea6efe2de9a8b543a03e41301bd5b24cd8e1f63e2 range=[7,27] unit=raw
 SG_ Synth_j2_16_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r16c08 digest=84a6ba13b3475b4d936ff25ae083891f9ba8b8dde2acf19ceb92f2ec28ae8eba range=[8,28] unit=raw
 SG_ Synth_j2_16_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r16c09 digest=93e715e0cb0c06f1cbcdef76b82c770aba3d12b21866f43a7e0ee39f7b7d885a range=[9,29] unit=raw
 SG_ Synth_j2_16_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r16c10 digest=b3569fb60bf2d94221d4830b9f550ef474a87934c78c0893d2f12ca6390f29ae range=[10,30] unit=raw
 SG_ Synth_j2_16_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r16c11 digest=8d02c1139606e1dde54f2e8c35cf5456507715897de64de5d9c1d26583572c69 range=[11,31] unit=raw
 SG_ Synth_j2_16_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_16: 8 j2
; peer-ref j2->j1 blk=16 sticky=1
; peer-ref j2->j6 blk=16 sticky=1
; peer-ref j2->j10 blk=16 sticky=1
; blk 17 slice j2 calibration notes for field desk operators
; map j2 r17c00 digest=288a73f78dcd8f6ccffc453acd7c53720106f256c177555ed9fe62cde2d3081f range=[0,20] unit=raw
 SG_ Synth_j2_17_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r17c01 digest=323e5d0ec3c081e948a88badc402d9460ed150472df330f96fbc4635aba05a61 range=[1,21] unit=raw
 SG_ Synth_j2_17_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r17c02 digest=7e7b047d1648f96d0f757a5e167f6c0b8905fed701d42ffdba40a16057e045d7 range=[2,22] unit=raw
 SG_ Synth_j2_17_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r17c03 digest=5f6a36e1c96791d8ba989b5b22cabe4953a965e2c394cbc9f155bb78f9432c8b range=[3,23] unit=raw
 SG_ Synth_j2_17_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r17c04 digest=171cf761232438198f2dbc480da6804117122b72fb1692012f6fe27158e973d4 range=[4,24] unit=raw
 SG_ Synth_j2_17_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r17c05 digest=785fe379ea766f741b11bb6061a0ac06a2cf4b3d1f7e0761506b5497fc0fadf8 range=[5,25] unit=raw
 SG_ Synth_j2_17_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r17c06 digest=85ef48e9faa86178a5af4ecdb500e6745c91c4add99976ec614c9af3d5e30a90 range=[6,26] unit=raw
 SG_ Synth_j2_17_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r17c07 digest=8f346d619b2906559492c9592531885616fa4a47e5c4ff3e56a22557f1475ace range=[7,27] unit=raw
 SG_ Synth_j2_17_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r17c08 digest=6e1ab8d97ade22ab591e4baa92243c51b1fb141f5b92d06debeed0234b076b17 range=[8,28] unit=raw
 SG_ Synth_j2_17_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r17c09 digest=5a0aeae706033c872e42d7b0ddbe680b3b0579b67720c7537c53ab33d10074e2 range=[9,29] unit=raw
 SG_ Synth_j2_17_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r17c10 digest=12d5cc919558a096c13def30ad15f46620bf5088ae352312ebe34be667c53a29 range=[10,30] unit=raw
 SG_ Synth_j2_17_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r17c11 digest=c20d691780fbbd67c5a13b8f2f92a6bf6f721ffd7463eb5be1829cedf0bcf808 range=[11,31] unit=raw
 SG_ Synth_j2_17_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_17: 8 j2
; peer-ref j2->j1 blk=17 sticky=1
; peer-ref j2->j6 blk=17 sticky=1
; peer-ref j2->j10 blk=17 sticky=1
; blk 18 slice j2 calibration notes for field desk operators
; map j2 r18c00 digest=92bd74825414c30d8953bea98b69447cdb4e53a4481bc4cd626028c4678d18b7 range=[0,20] unit=raw
 SG_ Synth_j2_18_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r18c01 digest=6a03109cb0bdb3a3f54522bd7bc2461a73506bd416b6e4c62cab80208d569241 range=[1,21] unit=raw
 SG_ Synth_j2_18_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r18c02 digest=f6c654c753666c5f2832877d3dcd9bc334346d991456b31e306ef1c94956c18e range=[2,22] unit=raw
 SG_ Synth_j2_18_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r18c03 digest=e02a5f0efb88991ba321b728e405a771dbca848a0362c85bf460fd0bf30fcf5f range=[3,23] unit=raw
 SG_ Synth_j2_18_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r18c04 digest=eb7c0ace07597ac94b86571195f7b19ed355c52edad640d6ec74f498f3423b03 range=[4,24] unit=raw
 SG_ Synth_j2_18_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r18c05 digest=69878f562d91435a3e89b1fbf9ecfb37daec4bb92badc1a31e4016d0528a8d8b range=[5,25] unit=raw
 SG_ Synth_j2_18_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r18c06 digest=b528925ed568c9c8d7ddd91dea3054acadf5584392e3657a295ddee66d72fbe9 range=[6,26] unit=raw
 SG_ Synth_j2_18_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r18c07 digest=172d61250595176eda3ef7dca2e515bc092e3873a7bd816b18692cd57db1508f range=[7,27] unit=raw
 SG_ Synth_j2_18_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r18c08 digest=e5c9c34d10217556ab12d6fd9706935ed0f5698a59ecd385d7644a6ab1c9aa7c range=[8,28] unit=raw
 SG_ Synth_j2_18_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r18c09 digest=6e2b26614780850f37c324e3168fc5f57e599aea877d56a38f516574444b40c5 range=[9,29] unit=raw
 SG_ Synth_j2_18_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r18c10 digest=084c4a363b6d9683ff4109586ac8836a34fb47e04bb7a6bb3786d89e3526b13b range=[10,30] unit=raw
 SG_ Synth_j2_18_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r18c11 digest=9cfbde7d8f5736cd08263414f3f5f57fdcd5295d0809cd9a35ebb545bf6a3574 range=[11,31] unit=raw
 SG_ Synth_j2_18_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_18: 8 j2
; peer-ref j2->j1 blk=18 sticky=1
; peer-ref j2->j6 blk=18 sticky=1
; peer-ref j2->j10 blk=18 sticky=1
; blk 19 slice j2 calibration notes for field desk operators
; map j2 r19c00 digest=ee44a8444cd8b273ae3a26651aa14f66e515e90f7c965bdba40fd10e4b7bddeb range=[0,20] unit=raw
 SG_ Synth_j2_19_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r19c01 digest=55bd04834b94626619f9924f6de234e046d0c0ea7ba9a533bde64710fe53addd range=[1,21] unit=raw
 SG_ Synth_j2_19_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r19c02 digest=c9cd4728cf594f7ba33943885b92d95dc59b3a948f1dcc76b9a2cdb77462345c range=[2,22] unit=raw
 SG_ Synth_j2_19_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r19c03 digest=8dd76665c3fb27021ca6453a12515def7ac11416c00c7f0ef490f58ea57cf095 range=[3,23] unit=raw
 SG_ Synth_j2_19_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r19c04 digest=63cf629bc7e024153d80a30b08687eaaa1af1e35877c1a87752b180a63e3cab6 range=[4,24] unit=raw
 SG_ Synth_j2_19_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r19c05 digest=3c91a831f5399f9fdfeadbbd86bd3bb031a7f6d40e8269285462e96f312d583e range=[5,25] unit=raw
 SG_ Synth_j2_19_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r19c06 digest=4f6d1fa3cfc17d67b54e266db3b0e3627b919998d624cc13bbb7dbed0b1b1d47 range=[6,26] unit=raw
 SG_ Synth_j2_19_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r19c07 digest=237a69d6103b3e8010684eef838586bf18ea1960f79f13db8f9e1d9eefec7501 range=[7,27] unit=raw
 SG_ Synth_j2_19_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r19c08 digest=78a23365c7857665638317aa51beef88a3a0abf62e232a1b2e9d696470e1b6a5 range=[8,28] unit=raw
 SG_ Synth_j2_19_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r19c09 digest=d5df92133bb6c16379ced73049c6a3a21363d71bc5759d10caa70975cdb1c7db range=[9,29] unit=raw
 SG_ Synth_j2_19_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r19c10 digest=a55ba31dfe3c6e59eed50a9a125e87d25fd4a4ab20ebe27a46ea4617aa393783 range=[10,30] unit=raw
 SG_ Synth_j2_19_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r19c11 digest=8b00f805834b98caa0380a1f3822c58c975fde47602c3f8329553f782686ce7c range=[11,31] unit=raw
 SG_ Synth_j2_19_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_19: 8 j2
; peer-ref j2->j1 blk=19 sticky=1
; peer-ref j2->j6 blk=19 sticky=1
; peer-ref j2->j10 blk=19 sticky=1
; blk 20 slice j2 calibration notes for field desk operators
; map j2 r20c00 digest=0a306985d071670d0b1fde7e207a636d406fe0e77baa44de5d8faf37d9192b8c range=[0,20] unit=raw
 SG_ Synth_j2_20_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r20c01 digest=8a7be236632581cb01e2ff8500820c370442ac39cc50f061c13f15675be954bc range=[1,21] unit=raw
 SG_ Synth_j2_20_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r20c02 digest=9963eb675680ceefdb36f17ea6b146c2026df7508aa62029df0ce711828893d9 range=[2,22] unit=raw
 SG_ Synth_j2_20_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r20c03 digest=8e9a91fd168b566fff22f053a0d1d5a6f1937ff5c302695769c2662c929c1de8 range=[3,23] unit=raw
 SG_ Synth_j2_20_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r20c04 digest=ffe46bfa1c78924c37d6dd7129ce741b2b4ad1a9b90e4c3b26e3467da0394a34 range=[4,24] unit=raw
 SG_ Synth_j2_20_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r20c05 digest=4f8cc1efba115b2fb67b28e1b55dc8b373ce548379ebf8fc520ff4b4836bc437 range=[5,25] unit=raw
 SG_ Synth_j2_20_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r20c06 digest=de9d27b7af97e438e382239e14841b88811b4229d0d02d7f70d6159a70f23159 range=[6,26] unit=raw
 SG_ Synth_j2_20_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r20c07 digest=acfc356e028c4d5b84cc0ceb55fc81e30a42bb990cce3f3d29e1e967c5a6889e range=[7,27] unit=raw
 SG_ Synth_j2_20_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r20c08 digest=0148cda45a2e8b3ae873aa4d5a4e78d8515de21fd5d90b5a1cd50c78113b3b10 range=[8,28] unit=raw
 SG_ Synth_j2_20_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r20c09 digest=ddca9a7f6c518e45bb1f2cfa980360fa6b6770b84729d930f7d74b79431fa8bc range=[9,29] unit=raw
 SG_ Synth_j2_20_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r20c10 digest=bc8b8d44fe27f6b913f46b86e76d8c42ea908d66f335d7dff12247e42596f30b range=[10,30] unit=raw
 SG_ Synth_j2_20_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r20c11 digest=3189442e08f6c7642e455108f8073a86970bc1fc34d1633f63ab13bc30c4ad5e range=[11,31] unit=raw
 SG_ Synth_j2_20_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_20: 8 j2
; peer-ref j2->j1 blk=20 sticky=1
; peer-ref j2->j6 blk=20 sticky=1
; peer-ref j2->j10 blk=20 sticky=1
; blk 21 slice j2 calibration notes for field desk operators
; map j2 r21c00 digest=c0c37ebdd468fcd66ecd88d110d642062eac998fda180f0f099f604ab49c8d58 range=[0,20] unit=raw
 SG_ Synth_j2_21_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r21c01 digest=bd7815f2b04ab55b6ea5f995653f2bf0cf049eb02094879c59a194f66eb9d744 range=[1,21] unit=raw
 SG_ Synth_j2_21_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r21c02 digest=9a11bad6de0f9bc5dc6dd05b2c5960f50cf7bff52901018e06afb30bce4854f3 range=[2,22] unit=raw
 SG_ Synth_j2_21_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r21c03 digest=018dacbeff558968b92c1968429c433bb76b8719cc3fe52261cb417dd009afca range=[3,23] unit=raw
 SG_ Synth_j2_21_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r21c04 digest=ff1545d89ec726b3d281487abcc86fbb64a6f29485d5da6a7c41d9eabe110003 range=[4,24] unit=raw
 SG_ Synth_j2_21_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r21c05 digest=0da70ce6dea11792b94163cc00a876429dd7115de91f6c9deea40b0633999e26 range=[5,25] unit=raw
 SG_ Synth_j2_21_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r21c06 digest=abca4e867693f4f58d02b3e3890fbab7ca66aafacbc45f30998d90b038d9e536 range=[6,26] unit=raw
 SG_ Synth_j2_21_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r21c07 digest=029743a77c07af6561bd72cb8ab8944caa63df756d7c278b0665eeec1fe5ed19 range=[7,27] unit=raw
 SG_ Synth_j2_21_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r21c08 digest=596228d8274032d2d4ade816e72133c3a1cd84c0f60cef3e062e56ae2fe67de3 range=[8,28] unit=raw
 SG_ Synth_j2_21_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r21c09 digest=725bd0f3a6bb294d23fa7e13e252baba9e47c2bae37d467f8b284dbb8c07a8d1 range=[9,29] unit=raw
 SG_ Synth_j2_21_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r21c10 digest=9675bb8fa1befd04bdf315ee8fb50b28b5e38530b1a2f78abf61e0adaee0043d range=[10,30] unit=raw
 SG_ Synth_j2_21_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r21c11 digest=f0ef6d557aed8e605b7a37ced4e0de2e426a781b02a190b52e91514148e29715 range=[11,31] unit=raw
 SG_ Synth_j2_21_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_21: 8 j2
; peer-ref j2->j1 blk=21 sticky=1
; peer-ref j2->j6 blk=21 sticky=1
; peer-ref j2->j10 blk=21 sticky=1
; blk 22 slice j2 calibration notes for field desk operators
; map j2 r22c00 digest=23843c4e2763f4e47a1f8eb1b795c533e6964fde9e62a7ddc09a2062aa7d2051 range=[0,20] unit=raw
 SG_ Synth_j2_22_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r22c01 digest=fb4a19d30d79fa68d42efd7315f3931b2f931feb6c053acce3bb18310aea91f9 range=[1,21] unit=raw
 SG_ Synth_j2_22_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r22c02 digest=3c6f48287334309b2deaaa076b6bf1aedf2ffb1e90eff269bdd4020aa323226f range=[2,22] unit=raw
 SG_ Synth_j2_22_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r22c03 digest=566ebeab4b914cdb0d4fae07863f57bc30876271dce3b3fdfd86d08687f16dcb range=[3,23] unit=raw
 SG_ Synth_j2_22_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r22c04 digest=bea4eea5e9e91f1f6bb18105f3ea2785b5be13b356309ab48506cd69cd955b34 range=[4,24] unit=raw
 SG_ Synth_j2_22_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r22c05 digest=e0687f86529dcf489506fa183bbcf216546fce259d32f0d7577c2a8936ba4aab range=[5,25] unit=raw
 SG_ Synth_j2_22_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r22c06 digest=5eae5fba57c65886270c0f48d41daeeb7c768460e41653a8cfbfc1a716dfecac range=[6,26] unit=raw
 SG_ Synth_j2_22_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r22c07 digest=34458bfb9b9e33f1e8964c7fe2bd46300ca6440e66e716819f713af0549a14d1 range=[7,27] unit=raw
 SG_ Synth_j2_22_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r22c08 digest=7832082eebe3d73fe415dd43ee8f96516706c525246877b185368314acb4fc44 range=[8,28] unit=raw
 SG_ Synth_j2_22_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r22c09 digest=87e467fc91b45f0ff0573c786f54bb4e9010acffd876a8e60695c8678719ddeb range=[9,29] unit=raw
 SG_ Synth_j2_22_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r22c10 digest=3d8c534a469c6a0e7fc40dcce33497acfff4902abe068df816de325ed85d5cda range=[10,30] unit=raw
 SG_ Synth_j2_22_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r22c11 digest=a1137344433c4cc63c1f778ab7537c540d2f6e2f34312515f4d3918ad713160f range=[11,31] unit=raw
 SG_ Synth_j2_22_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_22: 8 j2
; peer-ref j2->j1 blk=22 sticky=1
; peer-ref j2->j6 blk=22 sticky=1
; peer-ref j2->j10 blk=22 sticky=1
; blk 23 slice j2 calibration notes for field desk operators
; map j2 r23c00 digest=21cb2348c2a2ad3cf4abfccae0de8664d3674ea1829d5c613488bbebfc8f31a4 range=[0,20] unit=raw
 SG_ Synth_j2_23_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r23c01 digest=6187c025f04eb17dd88257221a452a9af4fd78af396f68688fbe105bbb3180a2 range=[1,21] unit=raw
 SG_ Synth_j2_23_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r23c02 digest=c77f4f3e2b465012c0c57d02d2e7981e9fdb91a6a0214c9a2bcff20953654329 range=[2,22] unit=raw
 SG_ Synth_j2_23_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r23c03 digest=b2d120037e023d2a0f33e2fa20abb732a6505655795aeaec022e3057556a8ba7 range=[3,23] unit=raw
 SG_ Synth_j2_23_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r23c04 digest=99fd3ef86088b88ed06bfb767d7f1500f1c1c6263738d496da60a0ca3974da51 range=[4,24] unit=raw
 SG_ Synth_j2_23_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r23c05 digest=5316f5c55d3b3fb3c87025ca7973726c7a09aca698651dfc3226b99ff566306a range=[5,25] unit=raw
 SG_ Synth_j2_23_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r23c06 digest=45404cd4625144db839e3e3480103f114fd770139af362c5bf239fd3e3e97a34 range=[6,26] unit=raw
 SG_ Synth_j2_23_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r23c07 digest=439df9592c8089f781d4de040601bdeedb94f8c2fadef9439cd85339135325ca range=[7,27] unit=raw
 SG_ Synth_j2_23_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r23c08 digest=f573e2e12b355055d4ad585d234441476b549a3e156bcd9880e2033bb35bcbe0 range=[8,28] unit=raw
 SG_ Synth_j2_23_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r23c09 digest=8f6ef820ed3d4aee1c8d759e5254c9a2784e25e61ef6481d3457b86eab446ef6 range=[9,29] unit=raw
 SG_ Synth_j2_23_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r23c10 digest=5cb5135f85e6710f1083a80655a3423156369495c8420678f4d42fadcb33f093 range=[10,30] unit=raw
 SG_ Synth_j2_23_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r23c11 digest=68b9ce3de227845fae2358a49b818544d6939239449ba9ba6fdc7203fa482f4d range=[11,31] unit=raw
 SG_ Synth_j2_23_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_23: 8 j2
; peer-ref j2->j1 blk=23 sticky=1
; peer-ref j2->j6 blk=23 sticky=1
; peer-ref j2->j10 blk=23 sticky=1
; blk 24 slice j2 calibration notes for field desk operators
; map j2 r24c00 digest=5878ab8789d626f53c6d9e8ccf0350fdbb067c29b9d24c9aecaa9097f9d6c1ce range=[0,20] unit=raw
 SG_ Synth_j2_24_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r24c01 digest=f9be5092f43b9a2d5cfb3c3934caff123b5611d321167f9991c174231a45b078 range=[1,21] unit=raw
 SG_ Synth_j2_24_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r24c02 digest=469182fae839306d49ffcd35238d23f89393f0370f519a85d23e2d0f6284a3cf range=[2,22] unit=raw
 SG_ Synth_j2_24_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r24c03 digest=31d7aef62398c90e35c9cf5a65c400c2d8d6ac595fe103927d197e49cf306ae3 range=[3,23] unit=raw
 SG_ Synth_j2_24_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r24c04 digest=9100b020c0df5c2e4f619b6b78ed870c66f2770b4dcba2a6a53ffc7e63dcdce8 range=[4,24] unit=raw
 SG_ Synth_j2_24_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r24c05 digest=795278290ddd07b717fb8826735a93e79f7e1f0922369c672f31e15c04a96e80 range=[5,25] unit=raw
 SG_ Synth_j2_24_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r24c06 digest=38f29d3a7820bd80cdaa56d2d8e17c87c1d8c8178bf85c51fce22585ffc06234 range=[6,26] unit=raw
 SG_ Synth_j2_24_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r24c07 digest=a610193e70d1f7807d621951dfd6a47d96b8837a018cfb4369b99cc29474088b range=[7,27] unit=raw
 SG_ Synth_j2_24_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r24c08 digest=f22c2374d3bce65905e227ae6fd125382118fd6023380687363376da82fd72c7 range=[8,28] unit=raw
 SG_ Synth_j2_24_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r24c09 digest=0f7462926b77ce9475cb8b8057eaff69e91cd2cdae99bc0bcdc513807f2c3d52 range=[9,29] unit=raw
 SG_ Synth_j2_24_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r24c10 digest=1241e152abe08bc248e0eecdd20a76d5d51b50077453c18354001f56b48a93ad range=[10,30] unit=raw
 SG_ Synth_j2_24_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r24c11 digest=d104169fade3100442cf9b16bc3ef9eab025ccf80b884250dfc6cb3481a200fc range=[11,31] unit=raw
 SG_ Synth_j2_24_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_24: 8 j2
; peer-ref j2->j1 blk=24 sticky=1
; peer-ref j2->j6 blk=24 sticky=1
; peer-ref j2->j10 blk=24 sticky=1
; blk 25 slice j2 calibration notes for field desk operators
; map j2 r25c00 digest=f5c90143cee377380b12713ff3a3229e8e16a959183e26a04afda361877f4d29 range=[0,20] unit=raw
 SG_ Synth_j2_25_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r25c01 digest=7663fcfde27b9f5d294ba6a5aaff008f40d76d54e729f39bb49111e1c5381a4b range=[1,21] unit=raw
 SG_ Synth_j2_25_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r25c02 digest=f7a71af82121b9f08aa96676e927770257afcf89f2e14a77b89275dec50b0c2e range=[2,22] unit=raw
 SG_ Synth_j2_25_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r25c03 digest=41589d6d6d568302adbef2193bf9acd12c86f2bece957f6b36d4261aa25d0031 range=[3,23] unit=raw
 SG_ Synth_j2_25_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r25c04 digest=61533187a8984094a7e6869134a435af58314fadec89bdc93ed279f385fc1b0e range=[4,24] unit=raw
 SG_ Synth_j2_25_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r25c05 digest=5dd9b9ed6f0f37a98da30daeeda5bcc138ed041661a9fce0b3da2916bdc88279 range=[5,25] unit=raw
 SG_ Synth_j2_25_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r25c06 digest=e73a8545d2b6edd68a41bf6db50a10bf37f222d5bb7cf2009f55c64e1a3e05fd range=[6,26] unit=raw
 SG_ Synth_j2_25_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r25c07 digest=ec4006a6d4c8cd054c4177afcb938dc85e73a7ad5e861e34328276c0ec083b15 range=[7,27] unit=raw
 SG_ Synth_j2_25_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r25c08 digest=7e67fee62167ab4143fedc2c285842894ff8cc21638924852d4cfbfb9de8d1d7 range=[8,28] unit=raw
 SG_ Synth_j2_25_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r25c09 digest=91b8cc54ec4f76b3fdbb2f8a0202071363408c266fb20a70dbbf95c0571824f2 range=[9,29] unit=raw
 SG_ Synth_j2_25_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r25c10 digest=55f99625d3d8b6d6749a36de70eaa2a99f367d0c3d1c00ea6420f289b1798705 range=[10,30] unit=raw
 SG_ Synth_j2_25_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r25c11 digest=d75440110ddf072cb933625a655c495c1a580ec0c4b82f42841083de339be6c5 range=[11,31] unit=raw
 SG_ Synth_j2_25_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_25: 8 j2
; peer-ref j2->j1 blk=25 sticky=1
; peer-ref j2->j6 blk=25 sticky=1
; peer-ref j2->j10 blk=25 sticky=1
; blk 26 slice j2 calibration notes for field desk operators
; map j2 r26c00 digest=9b05136b78a279456f3bb9cd1ce4a7ba2cd3fbacfb2bc0b7020031fdf1de5d4f range=[0,20] unit=raw
 SG_ Synth_j2_26_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r26c01 digest=46f52184cdf554d00d06875524f86b1961e5dc7b769b7bedabb8ce54777b229e range=[1,21] unit=raw
 SG_ Synth_j2_26_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r26c02 digest=31200bf2cf1dbad805646d3337e6c3cc7dfd096167f88c5fd7718fb5d21df578 range=[2,22] unit=raw
 SG_ Synth_j2_26_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r26c03 digest=bcef888a5a40a4dd8df64c6e6f10eb70a0eaf3348c8f47587a7046995f1c74ed range=[3,23] unit=raw
 SG_ Synth_j2_26_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r26c04 digest=3edbe84d573bcf96ff8217d8ea3ebf7ff1507fa52a9926b20660d657ede70955 range=[4,24] unit=raw
 SG_ Synth_j2_26_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r26c05 digest=e467220d32e18842f989a68ca9b07b16196f500b2a03b67b032b3b39b5557e26 range=[5,25] unit=raw
 SG_ Synth_j2_26_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r26c06 digest=2940d1d22897290c0553e1ac1d06029ea0d98101427af7575e6fa1a2ff958cae range=[6,26] unit=raw
 SG_ Synth_j2_26_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r26c07 digest=bfdac5c10fde75923872c4ba5114b65f190b687ca747b0625d97e30d7b2fefea range=[7,27] unit=raw
 SG_ Synth_j2_26_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r26c08 digest=5291564cd4a7ddb0a9476b3dfbaa20a4671b39146c3afb50e94926dbf4f0acd7 range=[8,28] unit=raw
 SG_ Synth_j2_26_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r26c09 digest=661f5bdab65b09500e0c8b64883e184ed104ffb5a7c8a7a65a9a37ba1b5ac7b1 range=[9,29] unit=raw
 SG_ Synth_j2_26_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r26c10 digest=9c20a386d02c7054c34deeb0a79606e24dad1380247379d2c305e5cde7eac8d8 range=[10,30] unit=raw
 SG_ Synth_j2_26_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r26c11 digest=ac55522d0d7e18bf2ffe85b8bda8e23ea703974beb7b9e0d476606141d160384 range=[11,31] unit=raw
 SG_ Synth_j2_26_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_26: 8 j2
; peer-ref j2->j1 blk=26 sticky=1
; peer-ref j2->j6 blk=26 sticky=1
; peer-ref j2->j10 blk=26 sticky=1
; blk 27 slice j2 calibration notes for field desk operators
; map j2 r27c00 digest=73a8b93513ec497b89fb10577f93c6f5dadecc7409b41a3b89ebc07c80e190dc range=[0,20] unit=raw
 SG_ Synth_j2_27_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r27c01 digest=ff7c4ce723fc8ebdc89f3dac731d035fc26359e67e072dc8f297ccdc985ab2e3 range=[1,21] unit=raw
 SG_ Synth_j2_27_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r27c02 digest=ff99b2d82e70712ba4115a814657509a15e9fda236f4c32cda119e40eced134f range=[2,22] unit=raw
 SG_ Synth_j2_27_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r27c03 digest=01bd33a968a01f7a169e8ea06898f34d11ba88238cf8903a876af2a9c69350a8 range=[3,23] unit=raw
 SG_ Synth_j2_27_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r27c04 digest=b078cd83c18d7bf9e2923eb439fdd4d0dc99208b09106c0de7165237d017410e range=[4,24] unit=raw
 SG_ Synth_j2_27_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r27c05 digest=95c03138314842801a03b1874069a212b7143b68ec266b68c2fce257dc353235 range=[5,25] unit=raw
 SG_ Synth_j2_27_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r27c06 digest=2fe04736c0718bdcae558298ac2bd2b81b0c4bbf73a5c885a3f93d262f6a0a0e range=[6,26] unit=raw
 SG_ Synth_j2_27_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r27c07 digest=50e88a4baa01f26c2340eb9379860a32d313085ff76373f8f383a42183069108 range=[7,27] unit=raw
 SG_ Synth_j2_27_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r27c08 digest=860c089bff2798c921bea739c653cffd8e7e83abdd7ef8f38046918f313618df range=[8,28] unit=raw
 SG_ Synth_j2_27_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r27c09 digest=8dee6660d879989d0e29c3513a0b42afd1790ef8900c45d943b9e55377bd0e52 range=[9,29] unit=raw
 SG_ Synth_j2_27_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r27c10 digest=ee9c018522ede8749896f3f2e3aeace525d91deb65d29f7f3fce655ccde49504 range=[10,30] unit=raw
 SG_ Synth_j2_27_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r27c11 digest=c14ef260a2203aed9a05b710b4784dfb3b1cca5ae290679fa5519741263e0569 range=[11,31] unit=raw
 SG_ Synth_j2_27_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_27: 8 j2
; peer-ref j2->j1 blk=27 sticky=1
; peer-ref j2->j6 blk=27 sticky=1
; peer-ref j2->j10 blk=27 sticky=1
; blk 28 slice j2 calibration notes for field desk operators
; map j2 r28c00 digest=608996453f2f2016e23477cbe396db098a8b1c92325d7d39360cfe840dfdb13e range=[0,20] unit=raw
 SG_ Synth_j2_28_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r28c01 digest=60208c5629d5431c3f6f2e128fe896d5b6e2fa9a44d468c5fe1deec9c82567fe range=[1,21] unit=raw
 SG_ Synth_j2_28_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r28c02 digest=26daea122c2488e73509012512e8dc4acbbf4dd272c81ecf86db4e4049ceef68 range=[2,22] unit=raw
 SG_ Synth_j2_28_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r28c03 digest=ec2b8dcdb9e8a83de47e003cda8058e6016c178afbf8f73deb4476e19fca7cb3 range=[3,23] unit=raw
 SG_ Synth_j2_28_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r28c04 digest=ce83951d123e13084e3e4ca9fe6434fdd0370148bade28b9be44507c1a0db757 range=[4,24] unit=raw
 SG_ Synth_j2_28_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r28c05 digest=7e2d55608627e3d5278f62529cb7e01d5ba68df0a79d9bafb3671281b71abd70 range=[5,25] unit=raw
 SG_ Synth_j2_28_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r28c06 digest=f5cf53d1bf680889f8f3f31b1632c2507f5d7423b8ef3a707fbb8ea1109d6ef6 range=[6,26] unit=raw
 SG_ Synth_j2_28_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r28c07 digest=0ccad869ac498a4624b0c092e5a84560aef0a0e757c4df35b16288c888081740 range=[7,27] unit=raw
 SG_ Synth_j2_28_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r28c08 digest=7d8527e11bd09101b44eeb64f97c2a2c6b341cc46fca97a8d8d01b98ee1ab7c1 range=[8,28] unit=raw
 SG_ Synth_j2_28_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r28c09 digest=536b036d9655bd992c551132487ff394bdbae40ffec71de13a70c08467fe103b range=[9,29] unit=raw
 SG_ Synth_j2_28_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r28c10 digest=fb130f531f88cf5552a8bda9cfdf8bedce2119317e68e02d611b7edc3be58472 range=[10,30] unit=raw
 SG_ Synth_j2_28_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r28c11 digest=335f551ab74f4bce83efc31b2e8357b33acdefcadbbb5574bd85c494b8f7fa16 range=[11,31] unit=raw
 SG_ Synth_j2_28_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_28: 8 j2
; peer-ref j2->j1 blk=28 sticky=1
; peer-ref j2->j6 blk=28 sticky=1
; peer-ref j2->j10 blk=28 sticky=1
; blk 29 slice j2 calibration notes for field desk operators
; map j2 r29c00 digest=8824369c19ab018586132a1027f698dc1c3513a5363dc82f0e19d0962c04e749 range=[0,20] unit=raw
 SG_ Synth_j2_29_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r29c01 digest=ab4e6556e2fdbddcc657ec780b26ed6718a7698fa4cd0cc3f4adde87d5181724 range=[1,21] unit=raw
 SG_ Synth_j2_29_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r29c02 digest=b4c796d5eb3559242934c806c38acace67c4d3b4f24707ad0b8f8845340e903d range=[2,22] unit=raw
 SG_ Synth_j2_29_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r29c03 digest=832f8fc93c929d595826a14c5a41e90ac1fa0e5f0f9a30d2a63af13bcbe7ee47 range=[3,23] unit=raw
 SG_ Synth_j2_29_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r29c04 digest=ba73c6865abf9ddfc41bcbc86923e5754ff41bfefe0670b5c0edc38b33062494 range=[4,24] unit=raw
 SG_ Synth_j2_29_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r29c05 digest=b0106446dac4eca57257a53cb227359285f9292d156718037e86994004ec299e range=[5,25] unit=raw
 SG_ Synth_j2_29_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r29c06 digest=829e48f6795d812f1474c25e1e1bca50f20f5328eaedc67f04e67523a05a8db3 range=[6,26] unit=raw
 SG_ Synth_j2_29_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r29c07 digest=cc1ab588152d4ab962735305af1a3d966e374b67403d2efe0fdc637af3dba086 range=[7,27] unit=raw
 SG_ Synth_j2_29_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r29c08 digest=1ebac6bb988ab2aac0ab4f8079d4d2324ed8bceb32216845ac89dd169a64befe range=[8,28] unit=raw
 SG_ Synth_j2_29_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r29c09 digest=59524d6ac53fbddfdc3fc84deebccff2993b6d36b65a12ba78f91326955377cc range=[9,29] unit=raw
 SG_ Synth_j2_29_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r29c10 digest=94ce4329f214cac3fc868e4c96205680c40e875c95c4659612caf4edd9c3afa1 range=[10,30] unit=raw
 SG_ Synth_j2_29_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r29c11 digest=21ae6f6fd4ae9e6de85d419701f46f08680b2334560e810243b596cea692e6ee range=[11,31] unit=raw
 SG_ Synth_j2_29_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_29: 8 j2
; peer-ref j2->j1 blk=29 sticky=1
; peer-ref j2->j6 blk=29 sticky=1
; peer-ref j2->j10 blk=29 sticky=1
; blk 30 slice j2 calibration notes for field desk operators
; map j2 r30c00 digest=63dc98a87a8efe8eaa1bff26fef8f8b3b8a1d9fe5b0742200c5466fd92636ce5 range=[0,20] unit=raw
 SG_ Synth_j2_30_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r30c01 digest=5dee25de4baf7cf364b022c7097d17489b02c7129926fda20a25dd057302db6e range=[1,21] unit=raw
 SG_ Synth_j2_30_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r30c02 digest=8e54f5f2481c24b559357804d73cb077c4f3071d41513c941cd86493ca52fbfb range=[2,22] unit=raw
 SG_ Synth_j2_30_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r30c03 digest=299d08c1591d62ab58d959380fb64233832ffa55272cefd28b15e0432394f164 range=[3,23] unit=raw
 SG_ Synth_j2_30_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r30c04 digest=94b8e370d91a012ae9a6a3e03dff75ba2f64bedee12e63da22c10d89d2cd0a74 range=[4,24] unit=raw
 SG_ Synth_j2_30_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r30c05 digest=d221b89de11f7a4b7a0fa005bce66df484bdd660c1420fe589bae6a507479dab range=[5,25] unit=raw
 SG_ Synth_j2_30_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r30c06 digest=dadea3530a8db46e70517aacacc4769409d432b5743131442063320ec7858298 range=[6,26] unit=raw
 SG_ Synth_j2_30_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r30c07 digest=47db5b9fc20cfac3b7081817a6a039fa951e8b5add9d0a71779dc839286aca6a range=[7,27] unit=raw
 SG_ Synth_j2_30_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r30c08 digest=118dba6c92fc37f486cc7ed3dd9a80b0ca0b191001842508c3629b291a70e42f range=[8,28] unit=raw
 SG_ Synth_j2_30_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r30c09 digest=d432678162b75fe17cf5667e63b35ce9df5d9c67dc49b7b03e60c0b60ca01176 range=[9,29] unit=raw
 SG_ Synth_j2_30_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r30c10 digest=0522c28618db3456675d944f4d60821ecf2d7fd2d6fd613642261158e917153d range=[10,30] unit=raw
 SG_ Synth_j2_30_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r30c11 digest=0e2071c39c2eaea261d01e33ab76f0164d76f6dd09ea86a2cd02b02e9055c8d1 range=[11,31] unit=raw
 SG_ Synth_j2_30_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_30: 8 j2
; peer-ref j2->j1 blk=30 sticky=1
; peer-ref j2->j6 blk=30 sticky=1
; peer-ref j2->j10 blk=30 sticky=1
; blk 31 slice j2 calibration notes for field desk operators
; map j2 r31c00 digest=9a1b9a33c8a1c723d925abfd8ee9f3fbc3ef36839ccf45b018fef4f1f1ffa6f5 range=[0,20] unit=raw
 SG_ Synth_j2_31_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r31c01 digest=899718b5e6ae77803411c966e1bc58430b338784bec73dd67137667c19d3ed46 range=[1,21] unit=raw
 SG_ Synth_j2_31_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r31c02 digest=9265259d90b3d4b52f7d11366cccdb3c1157950cbac586521e85b5c16d1546a3 range=[2,22] unit=raw
 SG_ Synth_j2_31_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r31c03 digest=ab26530e4cbc4ae8ba6dd0ca41b005e353fd423d0173ae45c7ae44fe82b823bc range=[3,23] unit=raw
 SG_ Synth_j2_31_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r31c04 digest=763ca7ccafedc78a398f934cb2601d302fb068604d2e1401c67074048ff3c21b range=[4,24] unit=raw
 SG_ Synth_j2_31_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r31c05 digest=289d15a5e8a8a5ecc0c5cc79e6409e2ea62ecfe8aca26d6e77fee4ac79c5ea7d range=[5,25] unit=raw
 SG_ Synth_j2_31_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r31c06 digest=b4d4f51e3ae3fe0b137e2e0640bc75866d5eb3ff64427355d34a08d84a51a749 range=[6,26] unit=raw
 SG_ Synth_j2_31_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r31c07 digest=2a80ef575e6a405b6e67483a881aac4c8ba65f0acf13846a69de16381e4a2a26 range=[7,27] unit=raw
 SG_ Synth_j2_31_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r31c08 digest=b015000e18a24952dd9129289fecd30a6152168958b4245fdef9ede3783abbb7 range=[8,28] unit=raw
 SG_ Synth_j2_31_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r31c09 digest=a50b8a4aebf9e15deafe390f8d1e8a3efd4993beeeb053c16c65c57ccffa40ca range=[9,29] unit=raw
 SG_ Synth_j2_31_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r31c10 digest=f4b97acf731d376b4b2e8baa0e18b42f6b2faffbd8f899d2517df96e2349bd4a range=[10,30] unit=raw
 SG_ Synth_j2_31_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r31c11 digest=a133c3352adb4db710a9655d0ecd55dc22dc3ff3a3772d9a59630147ad2b6689 range=[11,31] unit=raw
 SG_ Synth_j2_31_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_31: 8 j2
; peer-ref j2->j1 blk=31 sticky=1
; peer-ref j2->j6 blk=31 sticky=1
; peer-ref j2->j10 blk=31 sticky=1
; blk 32 slice j2 calibration notes for field desk operators
; map j2 r32c00 digest=c01a646c244e8fb39bccfe93c163204e6d198e814cbb2a8dfb2764f38fe63b74 range=[0,20] unit=raw
 SG_ Synth_j2_32_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r32c01 digest=3f56ed546c284f4deee673ef953b26889c80c555bf42a377dc353ebd42be3e1b range=[1,21] unit=raw
 SG_ Synth_j2_32_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r32c02 digest=ab5fb615b851d8657d6814f6e8ba267d44059abef335095bd3ac8ec8c9a6a036 range=[2,22] unit=raw
 SG_ Synth_j2_32_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r32c03 digest=d302ef3b2031d6b7a30c38bdac4a31fea486e65b94ccff91b5225625b3c5c966 range=[3,23] unit=raw
 SG_ Synth_j2_32_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r32c04 digest=78005ac5e988933c0af1c75bb233e8f0e5daa5fdcbb6b21d7a13483bffb5564a range=[4,24] unit=raw
 SG_ Synth_j2_32_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r32c05 digest=badd3ccfe779452f1a6e01cadfd0eac98637dc712a3fe273a4e05cc52fc294cd range=[5,25] unit=raw
 SG_ Synth_j2_32_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r32c06 digest=2f7beeaade4c3dd78d2224b7520f402b84c98e9c623f72a82aa1c95281faf25c range=[6,26] unit=raw
 SG_ Synth_j2_32_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r32c07 digest=938a3fa9748aa119bfde2aa38a588192cbe6a75bfdf9c8381046f82bc35ffa41 range=[7,27] unit=raw
 SG_ Synth_j2_32_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r32c08 digest=3aba3645456b3e8bc892b32d0ebbc45e76213aa495e6b749ad8d12299333c2e5 range=[8,28] unit=raw
 SG_ Synth_j2_32_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r32c09 digest=f77dbc792e1e9a416d9d8d68a389e497e341c88c8b467fe276d04446cbf17029 range=[9,29] unit=raw
 SG_ Synth_j2_32_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r32c10 digest=1fc3413fdeb5f841233de7cc17331cc410a975f817ea3d8252c8e2a4002640d4 range=[10,30] unit=raw
 SG_ Synth_j2_32_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r32c11 digest=04f0486905d777a858034f308107fd7973c87771dc3b39f7f479f45ef08808e8 range=[11,31] unit=raw
 SG_ Synth_j2_32_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_32: 8 j2
; peer-ref j2->j1 blk=32 sticky=1
; peer-ref j2->j6 blk=32 sticky=1
; peer-ref j2->j10 blk=32 sticky=1
; blk 33 slice j2 calibration notes for field desk operators
; map j2 r33c00 digest=b198c9f8c0170b2f4670b305b5c5ee47fec967ea8dbebe338affa6f1b0146c18 range=[0,20] unit=raw
 SG_ Synth_j2_33_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r33c01 digest=a5e9fd89c7bb30a84eb75b021937ca42253d30ccd2ca137d724d23be961cc3a5 range=[1,21] unit=raw
 SG_ Synth_j2_33_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r33c02 digest=ce3d26ba8ee6aebb184d1586cf01dec701c0f7a597e42961533609c862cc5d45 range=[2,22] unit=raw
 SG_ Synth_j2_33_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r33c03 digest=15bd3cff13d6a5f292708dc7c1ad4c9a7dbe8b064ac6af1cbf4b8503336dcf19 range=[3,23] unit=raw
 SG_ Synth_j2_33_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r33c04 digest=b2de0daafdd7755df2cf6019d3c65dbe8e078e0b7b425c8e9d1059a76ad8dc67 range=[4,24] unit=raw
 SG_ Synth_j2_33_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r33c05 digest=7dfb33a42676a0d7da4d966bcdf2775e32ac97fcde4d52825cfafe59a85dbcb5 range=[5,25] unit=raw
 SG_ Synth_j2_33_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r33c06 digest=f94a68a28ae59fd364c61946e6424919ed95dffb3cbca500067827e85d02c3ca range=[6,26] unit=raw
 SG_ Synth_j2_33_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r33c07 digest=a1fb92adf072ccd6400d48fbc5ad9dcd79679efaa24aa1abfbe0b26c07a6a0ff range=[7,27] unit=raw
 SG_ Synth_j2_33_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r33c08 digest=f9a2a4917a5d9e717e1a087cfe5c528e8e3d4bd8998935567945738d410f6268 range=[8,28] unit=raw
 SG_ Synth_j2_33_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r33c09 digest=6d9fdd34a4a094b767c668bb776dcead140062f4f67c7ad1710bc7c8292be7e4 range=[9,29] unit=raw
 SG_ Synth_j2_33_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r33c10 digest=9bc8521759fab14bf78a27fd312e38a85cd7ec097bda05765e5795f83adbb958 range=[10,30] unit=raw
 SG_ Synth_j2_33_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r33c11 digest=65f50b158ed0bb6512810f68eb9ca0bbc1f7a0bb485b05d7e180e92ddc5062a9 range=[11,31] unit=raw
 SG_ Synth_j2_33_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_33: 8 j2
; peer-ref j2->j1 blk=33 sticky=1
; peer-ref j2->j6 blk=33 sticky=1
; peer-ref j2->j10 blk=33 sticky=1
; blk 34 slice j2 calibration notes for field desk operators
; map j2 r34c00 digest=9c8318dcecb7cc3c1bf402c3676987f1ef2ab1029b85c460f67ed99d81f416fc range=[0,20] unit=raw
 SG_ Synth_j2_34_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r34c01 digest=814db8cff1ec5a6d358c7228aa26d303fb9544f180bf8ed417b5bdfadd086dbe range=[1,21] unit=raw
 SG_ Synth_j2_34_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r34c02 digest=0d68a1392ba0d3057016de8d998463aaa7e3b904ace7dad1acdd6428523f2de7 range=[2,22] unit=raw
 SG_ Synth_j2_34_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r34c03 digest=3ffb84a4ffba31d8f667a85f31d0132e57e0c1af13cdf80845f0ea6aa18b6c44 range=[3,23] unit=raw
 SG_ Synth_j2_34_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r34c04 digest=39237c943a59c8a278dd863defe9bd5d7b9cdcd95797dd9620ebe87755d29be0 range=[4,24] unit=raw
 SG_ Synth_j2_34_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r34c05 digest=a12a48e1a738cf3cf0782cb8d5ec23271d3eb4bfdc1a413a89dfd86b63dba058 range=[5,25] unit=raw
 SG_ Synth_j2_34_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r34c06 digest=4356964d4e7a9685efd745299e133485ba886fab52d84fa0ca8e1cef8421df81 range=[6,26] unit=raw
 SG_ Synth_j2_34_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r34c07 digest=164bb2b880c1b50f7202beabe9d20ac18db3c861dfc28e7e35dba88f78ad5765 range=[7,27] unit=raw
 SG_ Synth_j2_34_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r34c08 digest=c36e4e7ce3ff3685f3f5ebaebadaca421bd67bd06ec4c0b64bd8d6441f105b2f range=[8,28] unit=raw
 SG_ Synth_j2_34_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r34c09 digest=db6d80f2cdd9bfc7c9e30308f4c77d16ccfd3071bc5e5a3a69e1d7df7d3eac97 range=[9,29] unit=raw
 SG_ Synth_j2_34_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r34c10 digest=8b11f60f792079850d00fda9a72dad2b2c93bbdaa75c59affa1fdb2c8beed8ba range=[10,30] unit=raw
 SG_ Synth_j2_34_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r34c11 digest=be9534a94accc9633f47c17f0d56bd34a4e06e54712edc05e0ae1acf759d20f3 range=[11,31] unit=raw
 SG_ Synth_j2_34_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_34: 8 j2
; peer-ref j2->j1 blk=34 sticky=1
; peer-ref j2->j6 blk=34 sticky=1
; peer-ref j2->j10 blk=34 sticky=1
; blk 35 slice j2 calibration notes for field desk operators
; map j2 r35c00 digest=8217d1f3e63efb1ece868c7148f916947be1ed837d3bd4cbf409d6b984378e23 range=[0,20] unit=raw
 SG_ Synth_j2_35_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r35c01 digest=aa4457c178f6a16be021a77915935800d4ac9e6410eb296e67e009f5da350a33 range=[1,21] unit=raw
 SG_ Synth_j2_35_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r35c02 digest=a82253ece6d14d9e9ff14d4ddcf8089f6fad020ddcd764c15ff5a2e7744f7d34 range=[2,22] unit=raw
 SG_ Synth_j2_35_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r35c03 digest=332fea21f123c55b2bb2d67b5a877e26b790775d7bdd5c969e7276dc3ba27886 range=[3,23] unit=raw
 SG_ Synth_j2_35_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r35c04 digest=e5c87cf018c7f607c66bf5d2e497f55470dbb1e352daec1e68436693539eab03 range=[4,24] unit=raw
 SG_ Synth_j2_35_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r35c05 digest=0219734539eb2b7d5460bb7c1d243c481b0042d0e97549aff383cc80182778b0 range=[5,25] unit=raw
 SG_ Synth_j2_35_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r35c06 digest=9e3cd583bb9cadf140d2ce78713a6053403b4d48c5542a2d4e94436cddbad340 range=[6,26] unit=raw
 SG_ Synth_j2_35_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r35c07 digest=ae6c6286727f6b24ff54c094298eace6b545fffde161e20de237bdcfc556392c range=[7,27] unit=raw
 SG_ Synth_j2_35_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r35c08 digest=720dc52ba23087cda5692d018b08ea7f7dddf614071518c19f0419eb786279d5 range=[8,28] unit=raw
 SG_ Synth_j2_35_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r35c09 digest=f87e773a5e3b13b0256920ae21677a3c0b35cdc282896a29ac07f7f29cede733 range=[9,29] unit=raw
 SG_ Synth_j2_35_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r35c10 digest=7295aae5d3658118790586ca6edd1ad47d50e819a8416238de0b2e2bcb5e8877 range=[10,30] unit=raw
 SG_ Synth_j2_35_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r35c11 digest=93abcfc39c21addf7bf05d9a3535ceb724b5e28e9deb40967bb8bcee2d1a21ad range=[11,31] unit=raw
 SG_ Synth_j2_35_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_35: 8 j2
; peer-ref j2->j1 blk=35 sticky=1
; peer-ref j2->j6 blk=35 sticky=1
; peer-ref j2->j10 blk=35 sticky=1
; blk 36 slice j2 calibration notes for field desk operators
; map j2 r36c00 digest=f86c3d8269ca59c3dd47adc698b2e44acce6d652c26bfbfd9b1389f7616e86fc range=[0,20] unit=raw
 SG_ Synth_j2_36_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r36c01 digest=ec8ffd960303f302233d339836f2e8e34960c84957984b61d219f536700d9da0 range=[1,21] unit=raw
 SG_ Synth_j2_36_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r36c02 digest=353c343c07b38faf470670d3ef073a874833807e0a435909e8690a3c2b353a41 range=[2,22] unit=raw
 SG_ Synth_j2_36_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r36c03 digest=809bb542b6e0049275ac12a6522edb6d7e1193c87209e5656836f54f0423a72c range=[3,23] unit=raw
 SG_ Synth_j2_36_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r36c04 digest=0638ad00f5928e926a704fb0fa7be856a5b44fed5123109589ad972be02ec20c range=[4,24] unit=raw
 SG_ Synth_j2_36_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r36c05 digest=6328f5b606e9ea8b162dd03d53fe587c3d8c7998f0777e56e159dd4bbf9ce065 range=[5,25] unit=raw
 SG_ Synth_j2_36_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r36c06 digest=e60c1186a8dae0ca9e26467e05b93f0751a0ec2c099ddbe6dc1490aea695b524 range=[6,26] unit=raw
 SG_ Synth_j2_36_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r36c07 digest=e0d8040f0846791179ea702c5265299253f88f8afec47f5cb1e88607a3e3fe60 range=[7,27] unit=raw
 SG_ Synth_j2_36_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r36c08 digest=468a79264b7dc8461f822c3b819c6f11cb5adf42ce011805dc4eacb4b390fa8f range=[8,28] unit=raw
 SG_ Synth_j2_36_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r36c09 digest=64d39bf41823c21a25568e481bc09239d36cc7c162065cb01bbe1470c118bf8a range=[9,29] unit=raw
 SG_ Synth_j2_36_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r36c10 digest=a1c7a8e510c6ad41ce2dcfaf5b44c21ffb47750d50da640508d822c12c214a8d range=[10,30] unit=raw
 SG_ Synth_j2_36_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r36c11 digest=7aaa57526ce24277176381417536a43af8e0d787b32317b4e94ecbd676f5d0e9 range=[11,31] unit=raw
 SG_ Synth_j2_36_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_36: 8 j2
; peer-ref j2->j1 blk=36 sticky=1
; peer-ref j2->j6 blk=36 sticky=1
; peer-ref j2->j10 blk=36 sticky=1
; blk 37 slice j2 calibration notes for field desk operators
; map j2 r37c00 digest=60b9e7f5c05e48bc2c3b585847f664c0bf7453b41d402bed8cebdf11e0b2be87 range=[0,20] unit=raw
 SG_ Synth_j2_37_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r37c01 digest=beadb1e816fd023cc817c1c72ff6ac5a5102c9dc3c0b40dad107d14040ff0ef2 range=[1,21] unit=raw
 SG_ Synth_j2_37_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r37c02 digest=7d8c6aaf2d11f0661b304792f6f1571f017aaa51daf4f8f2d404c5c31479065f range=[2,22] unit=raw
 SG_ Synth_j2_37_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r37c03 digest=557ddd698e40d5c08bc8fb2a52ba20c53cbf131c260c56b94a49ac3653a14666 range=[3,23] unit=raw
 SG_ Synth_j2_37_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r37c04 digest=4b72473485c77a85e655b5913824b5254f619b030e68eaed3327ac3a53fe0b78 range=[4,24] unit=raw
 SG_ Synth_j2_37_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r37c05 digest=2c2bda33df0da5b5c3071f568851073f92365aacab599056c120d73157449564 range=[5,25] unit=raw
 SG_ Synth_j2_37_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r37c06 digest=7d7fc33e8c08231badc11af247a8e484de6681ff8eb13775b8e64cb109abde23 range=[6,26] unit=raw
 SG_ Synth_j2_37_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r37c07 digest=9b6e990bee02ae8932458505b44938205513dd9acb2e3ff3a334ca212ec52840 range=[7,27] unit=raw
 SG_ Synth_j2_37_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r37c08 digest=f089fefbe5c9359ea68e2ab9d23e3a6c3cab5d225070c33759d56e5c8122f40b range=[8,28] unit=raw
 SG_ Synth_j2_37_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r37c09 digest=5a7c7b12f95496f660f18217ec14fb13f0cdad8a70426924636cdbca1097ea43 range=[9,29] unit=raw
 SG_ Synth_j2_37_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r37c10 digest=df6144f24bf77d097c61a1023ec45d32237de233d4fc8fbdc192551ef9c4f0e2 range=[10,30] unit=raw
 SG_ Synth_j2_37_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r37c11 digest=dbc439991a39ac072f819775ab7a476e85847bd87ac04957a3d48a7d73ee5317 range=[11,31] unit=raw
 SG_ Synth_j2_37_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_37: 8 j2
; peer-ref j2->j1 blk=37 sticky=1
; peer-ref j2->j6 blk=37 sticky=1
; peer-ref j2->j10 blk=37 sticky=1
; blk 38 slice j2 calibration notes for field desk operators
; map j2 r38c00 digest=e74afebdf92ed99e97214d66fe4b113d1bcb8a102c44b8076c6a13960422b41e range=[0,20] unit=raw
 SG_ Synth_j2_38_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r38c01 digest=3a3babb097d97b314150768ea3154b9795addecc6b25b423f9a5bbbe2e09b74e range=[1,21] unit=raw
 SG_ Synth_j2_38_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r38c02 digest=d331438187dbfca0aa7be584c5ace86f6c430aa9085d02b9b4dc468532387b8b range=[2,22] unit=raw
 SG_ Synth_j2_38_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r38c03 digest=936f37b5f5c63008b3c9e859f2f7138abca5f455dfbbcae13549acb27d904aa5 range=[3,23] unit=raw
 SG_ Synth_j2_38_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r38c04 digest=c9bb2bc163a522131ab412f24ad01b0f61cb15036da0b5f20ba00ddc8d7d7c26 range=[4,24] unit=raw
 SG_ Synth_j2_38_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r38c05 digest=a2cf2bd048368ead680c80d6edf91d6b4c220e97287fe0cffbe6ae511464ec12 range=[5,25] unit=raw
 SG_ Synth_j2_38_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r38c06 digest=af73f44a58e586305c5ae97d0c027625fe50d1c0c28796566172421c2973228e range=[6,26] unit=raw
 SG_ Synth_j2_38_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r38c07 digest=d90b1aadcfeabb979bdf96f94305dea2f2de6706ece9dfe982f2615147149b5f range=[7,27] unit=raw
 SG_ Synth_j2_38_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r38c08 digest=4a3f81a5144f056e807d2459327146e3acc4f5bd9a21900b5aa0d6ea487d84b9 range=[8,28] unit=raw
 SG_ Synth_j2_38_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r38c09 digest=a7a599db8c43c4e0fbbd0aee05e72989986711fd1f0fe6c263596551e4c0f6ca range=[9,29] unit=raw
 SG_ Synth_j2_38_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r38c10 digest=7d125fbb3cdeeb1743d74410bfc16a1d443c428e917cfb6f558e3f0fec1c2ccf range=[10,30] unit=raw
 SG_ Synth_j2_38_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r38c11 digest=f53d3cd23a6cd39731c83cf0bfd2dd534b31944c2e2177196bb39df9bf8266e7 range=[11,31] unit=raw
 SG_ Synth_j2_38_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_38: 8 j2
; peer-ref j2->j1 blk=38 sticky=1
; peer-ref j2->j6 blk=38 sticky=1
; peer-ref j2->j10 blk=38 sticky=1
; blk 39 slice j2 calibration notes for field desk operators
; map j2 r39c00 digest=189cc438b79d62599e2b7a805e3a91e5f7fd8f16072e04654572a9a8acf8b1b2 range=[0,20] unit=raw
 SG_ Synth_j2_39_0 : 0|8@1+ (0.1,0) [0|100] "x" j2
; map j2 r39c01 digest=d9c604ad4ffe8aac1bfc99877a788930e96c3a251862b4feca5ce9c146d50deb range=[1,21] unit=raw
 SG_ Synth_j2_39_1 : 5|8@1+ (0.1,1) [0|100] "x" j2
; map j2 r39c02 digest=f0884423e1aa762e3de6f9592159267d8727a789a3fafa45a29902a2c1328d2f range=[2,22] unit=raw
 SG_ Synth_j2_39_2 : 10|8@1+ (0.1,2) [0|100] "x" j2
; map j2 r39c03 digest=fb4a4e97dac0ee29c18178862aa5c9e792ef7b2a565f20967026b2e5f8887741 range=[3,23] unit=raw
 SG_ Synth_j2_39_3 : 15|8@1+ (0.1,3) [0|100] "x" j2
; map j2 r39c04 digest=2f3881d6769091b53c34c02bd8b8f1e6a891e356d898c216e8cc143b614c7478 range=[4,24] unit=raw
 SG_ Synth_j2_39_4 : 20|8@1+ (0.1,4) [0|100] "x" j2
; map j2 r39c05 digest=6330c4278e367a76b7eeb06c2deea3dce367fde9f6f1ceac0bcf00ce5db6811e range=[5,25] unit=raw
 SG_ Synth_j2_39_5 : 25|8@1+ (0.1,5) [0|100] "x" j2
; map j2 r39c06 digest=7be026855c219ebb8cf9b522edf1fa9e74b3439928847646a213913b121fcd98 range=[6,26] unit=raw
 SG_ Synth_j2_39_6 : 30|8@1+ (0.1,6) [0|100] "x" j2
; map j2 r39c07 digest=f2f37c02d68440f7e5bd89ccf3865a047a93767dead03be63724cdcc204cc7fd range=[7,27] unit=raw
 SG_ Synth_j2_39_7 : 35|8@1+ (0.1,7) [0|100] "x" j2
; map j2 r39c08 digest=e0d95b1109c88c6dbf8864a4ee1a10d705bfbf8f688c8d604642bbeef22ddaa5 range=[8,28] unit=raw
 SG_ Synth_j2_39_8 : 40|8@1+ (0.1,8) [0|100] "x" j2
; map j2 r39c09 digest=a47ec75b859b9922c13d564ce86195e593f287db54b6881fbbfa85aaf5ddf16f range=[9,29] unit=raw
 SG_ Synth_j2_39_9 : 45|8@1+ (0.1,9) [0|100] "x" j2
; map j2 r39c10 digest=afded147201149b3545bef7b3edff4b273ab6386f6940f795e398b2eace014f1 range=[10,30] unit=raw
 SG_ Synth_j2_39_10 : 50|8@1+ (0.1,10) [0|100] "x" j2
; map j2 r39c11 digest=9ff126b749e6df7a7abb60a6166c4b7f133e0b2fb6f85dcd789341d16e52e0ba range=[11,31] unit=raw
 SG_ Synth_j2_39_11 : 55|8@1+ (0.1,11) [0|100] "x" j2
BO_ j2_AUX_39: 8 j2
; peer-ref j2->j1 blk=39 sticky=1
; peer-ref j2->j6 blk=39 sticky=1
; peer-ref j2->j10 blk=39 sticky=1
